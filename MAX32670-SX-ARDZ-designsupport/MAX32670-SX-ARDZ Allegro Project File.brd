# Allegro board MAX32670-SX-ARDZ Allegro Project File.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 27.51,10.47 23.32,10.47 23.32,12.73 23.9,12.73 23.9,11.38 24.14,11.38 24.13,11.35 24.12,11.27 24.12,11.2 24.13,11.14 24.14,11.08 24.17,11.02 24.2,10.96 24.24,10.91 24.28,10.86 24.33,10.82 24.38,10.79 24.44,10.76 24.5,10.74 24.56,10.73 24.63,10.73 24.69,10.73 24.75,10.74 24.82,10.76 24.87,10.79 24.93,10.82 24.98,10.86 25.02,10.91 25.06,10.96 25.09,11.02 25.11,11.08 25.13,11.14 25.14,11.2 25.14,11.27 25.13,11.35 25.12,11.38 25.37,11.38 25.48,11.49 25.48,12.46 26.75,12.46 26.8,12.51 26.8,13.89 26.82,13.92 26.85,13.99 26.87,14.05 26.88,14.12 26.88,14.19 26.87,14.25 26.86,14.31 26.83,14.37 26.81,14.42 26.77,14.47 26.73,14.52 26.68,14.56 26.63,14.59 26.58,14.62 26.52,14.64 26.46,14.66 26.4,14.67 26.34,14.67 26.27,14.66 26.2,14.64 26.14,14.61 26.08,14.58 26.03,14.53 25.98,14.49 25.96,14.46 25.23,13.73 25.23,12.73 23.32,12.73 23.32,14.92 27.51,14.92
GND on TOP: 59.64,19.35 59.64,18.72 59.51,18.59 59.51,16.94 59.64,16.81 59.64,16.18 59.51,16.05 59.51,14.4 59.64,14.27 59.64,13.67 59.51,13.54 59.51,12.24 59.39,12.12 57.1,12.12 56.88,12.33 56.88,13.45 57.28,13.84 57.28,18.31 58.32,19.35
GND on TOP: 13.89,22.07 14.73,21.91 15.44,21.43 16.13,20.75 16.16,20.7 16.18,20.63 16.18,20.4 16.16,20.33 16.13,20.27 10.68,14.82 10.19,14.34 9.78,14.06 9.3,13.97 5.22,13.97 5.2,14.05 5.14,14.17 5,14.22 1.47,14.22 1.33,14.28 1.27,14.42 1.27,19.05 1.33,19.2 1.48,19.28 9.83,19.28 9.88,19.3 9.91,19.35 9.91,21.95 9.94,22.03 10.03,22.07
GND on TOP: outline of 131 points within 1.27,32.12 31.69,52.07
GND on TOP: 49.61,43.03 51.89,43.03 52.2,42.72 52.2,37.21 51.94,36.96 50.09,36.96 50.09,37.72 48.59,39.22 48.59,42.01
GND on TOP: outline of 339 points within 58.42,1.27 87.6,52.07
GND on TOP: outline of 295 points within 1.27,1.27 58.88,32.96
GND on TOP: 36.32,20.88 36.32,23.49 36.08,23.74 34.71,23.74 34.44,23.47 34.44,20.95 34.62,20.78 36.22,20.78
GND on TOP: 30.47,52.07 36.4,52.07 62.08,52.07 65.36,52.07 65.36,51.27 65.42,51.12 65.56,51.06 65.79,51.06 65.79,48.87 65.56,48.87 65.52,48.87 65.49,48.86 64.06,48.86 64.02,48.87 63.99,48.87 62.28,48.87 62.25,48.87 62.21,48.86 61.71,48.86 61.52,49.05 61.52,49.6 61.46,49.74 61.32,49.8 60.58,49.8 60.53,49.8 59.7,49.8 59.45,50.05 59.45,50.77 59.45,50.8 59.15,51.53 58.42,51.83 58.36,51.83 58.34,51.84 39.73,51.84 39.38,51.5 39.38,50 39.08,49.7 38.11,49.7 37.58,50.23 37.58,51.27 37.03,51.82 36.74,51.82 36.65,51.83 36.58,51.83 36.5,51.83 36.41,51.82 34.2,51.82 34.11,51.83 34.04,51.83 33.96,51.83 33.87,51.82 31.66,51.82 31.57,51.83 31.5,51.83 31.42,51.83 31.33,51.82 30.47,51.82
GND on TOP: 69.11,15.55 70.7,15.55 71.16,15.1 71.16,14.62 70.18,13.64 69.37,13.64 69.32,13.69 69.32,14.68 69.11,14.88
GND on TOP: 65.63,11.18 64.72,11.18 64.6,11.06 64.6,8.19 64.83,7.96 65.44,7.96 66.81,9.33 66.81,10.83 66.7,10.95 65.86,10.95
GND on TOP: 15.65,47.54 23.48,47.54 24.09,46.93 24.09,46.37 24.09,46.36 24.09,44.72 24.09,44.62 23.85,44.37 22.39,44.37 22.25,44.31 22.19,44.17 22.19,44.03 20.09,44.03 20.04,44.03 19.98,44.02 18.8,44.02 18.6,43.98 18.44,43.87 17.83,43.26 17.72,43.1 17.68,42.9 17.68,42.77 17.16,42.25 14.03,42.25 13.48,42.81 13.48,45.36
GND on TOP: 63.3,19.31 64.93,17.69 64.93,17.43 64.98,17.38 65.16,17.38 65.18,17.41 65.18,18.93 65.71,19.47 65.71,20.35 65.26,20.81 64.14,20.81 63.77,21.18 63.37,21.18 63.3,21.11
GND on BOTTOM: outline of 104 points within 78.27,1.27 87.63,52.07
GND on BOTTOM: 19.14,47.49 22.75,43.88 22.84,43.81 22.96,43.79 23.09,43.79 23.11,43.76 31.04,43.76 31.2,43.61 31.93,42.88 32.03,42.81 32.14,42.79 35.24,42.79 35.47,42.56 35.47,37.96 35.1,37.59 34.99,37.59 34.99,37.59 25.62,37.59 23.15,35.12 23.15,34.08 23.15,33.74 22.92,33.52 20.26,33.52 19.65,34.12 19.65,44.01 19.76,44.12 19.83,44.22 19.85,44.34 19.85,45.21 19.96,45.37 20,45.55 20,45.61 19.99,45.66 19.87,45.88 19.65,46 19.6,46.01 19.55,46.01 19.25,45.9 19.09,45.62 19.02,45.5 18.89,45.45 18.79,45.45 18.75,45.44 18.58,45.48 18.5,45.64 18.5,47.08 18.5,47.09 18.5,47.38 18.61,47.49
GND on BOTTOM: 1.52,52.07 7.44,52.07 7.71,51.8 7.71,49.75 9.11,48.35 15.74,48.35 17.46,46.62 17.46,42.4 17.25,42.19 15.29,42.19 15.15,42.13 15.09,41.99 15.09,39.95 15.15,39.81 15.29,39.75 17.25,39.75 17.46,39.54 17.46,36.33 17.18,36.06 15.96,36.06 15.84,36.07 15.73,36.07 14.68,35.64 14.25,34.6 14.3,34.23 14.44,33.88 14.44,32.4 14.42,32.33 14.41,32.27 14.41,32.21 14.33,32.13 1.42,32.13 1.31,32.18 1.27,32.28 1.27,51.82
GND on BOTTOM: outline of 96 points within 74.61,13.63 80.25,27.09
GND on BOTTOM: 17.3,13.72 17.48,13.72 18.09,13.11 18.09,9.66 18.11,9.54 18.18,9.45 19.36,8.27 19.45,8.2 19.57,8.18 23.3,8.18 23.48,8 23.48,7.79 23.21,7.52 21.26,7.52 21.14,7.5 21.04,7.43 20.57,6.96 17.32,6.96 17.02,7.26 17.02,13.44
GND on BOTTOM: outline of 227 points within 1.27,1.27 31.16,33.26
GND on BOTTOM: 38.35,26.16 38.48,26.16 38.64,26.02 38.85,25.96 38.89,25.96 39.33,25.51 39.43,25.45 39.55,25.42 41.45,25.42 43.36,23.52 43.36,23.14 43.38,23.02 43.45,22.92 44.14,22.23 44.24,22.16 44.36,22.14 45.35,22.14 46.77,20.71 46.87,20.65 46.99,20.62 48.11,20.62 48.21,20.52 50.93,20.52 52.02,19.43 52.02,17.4 51.56,16.94 45.7,16.94 45.57,17.02 45.42,17.04 44.96,16.59 45.42,16.13 45.44,16.13 45.51,16.08 45.59,16.06 45.59,15.27 45.03,14.71 44.55,14.71 43.26,13.41 41.17,13.41 40.36,14.22 40.36,15.6 41.29,16.52 42.7,16.52 42.84,16.58 42.9,16.73 42.9,18.33 42.84,18.47 42.7,18.53 41.08,18.53 38.2,21.41 38.2,26.01
GND on BOTTOM: 23.32,14.92 27.51,14.92 27.51,10.81 25.25,10.81 25.08,10.89 25.06,11.08 25.08,11.16 25.09,11.24 24.63,11.69 24.17,11.24 24.18,11.16 24.2,11.08 24.17,10.89 24.01,10.81 23.32,10.81
GND on BOTTOM: outline of 126 points within 12.33,1.27 69.52,2.82
GND on BOTTOM: 25.36,33.77 25.11,34.02 25.11,34.58 26.17,35.65 35.01,35.65 35.81,34.85 35.81,34.01 35.57,33.77
GND on BOTTOM: outline of 297 points within 19.84,32.82 79.08,52.07
GND on L2_GND: 68.87,52 69.02,52.07 87.63,52.07 87.63,1.27 11.53,1.27 11.29,1.51 11.29,2.19 11.31,2.37 11.32,2.54 8.89,4.97 6.46,2.54 6.47,2.37 6.49,2.19 6.49,1.44 6.32,1.27 1.65,1.27 1.27,1.65 1.27,18.47 1.27,19.08 1.35,19.22 1.5,19.28 9.83,19.28 9.88,19.3 9.91,19.35 9.91,32.13 1.42,32.13 1.31,32.18 1.27,32.28 1.27,51.82 1.52,52.07 7.52,52.07 7.73,51.85 7.73,50.85 7.73,50.79 8.45,49.08 10.16,48.37 11.46,48.75 12.36,49.77 13.69,49.77 13.72,49.77 14.44,50.07 14.75,50.8 14.74,50.83 14.74,51.85 14.96,52.07 67.71,52.07 67.86,52 67.91,51.85 67.91,51.8 68.36,51.35 68.82,51.8 68.82,51.85
GND on L3_PWR: 11.41,3.13 12.48,3.13 12.66,3.02 12.65,2.82 12.59,2.69 12.57,2.56 12.71,2.23 13.03,2.1 13.17,2.12 13.3,2.19 13.35,2.22 13.39,2.26 13.55,2.41 15.7,2.41 15.7,1.27 11.53,1.27 11.29,1.51 11.29,2.19 11.31,2.36 11.32,2.54 11.31,2.74 11.28,2.95 11.27,3
GND on L3_PWR: outline of 352 points within 1.27,1.27 87.63,52.07
GND on L3_PWR: 16.41,2.41 16.41,1.27 15.34,1.27 15.34,2.41 15.7,2.41 15.7,2.41
VCC_3130 on TOP (solid shape): 19.08,39.85 19.08,39.83 18.29,39.04 17.91,39.04 17.91,40.69 18.24,40.69
VCC_31334 on TOP (solid shape): 44.25,45.92 44.25,44.83 44.55,44.53 44.55,44.12 44.4,43.97 43.23,43.97 42.67,44.53 37.74,44.53 37.47,44.81 37.47,45.69 37.82,46.05 44.12,46.05
VCC_31334 on TOP: 12.64,46.95 11.85,46.16 10.43,46.16 10.22,45.96 10.22,42.96 10.35,42.84 12.2,42.84 12.69,42.35 13.27,42.35 13.27,45.45 13.63,45.81 13.63,46.55 13.22,46.95
VCC_31334 on TOP: 69.27,28.63 69.34,28.55 69.93,28.55 70.61,29.24 70.61,29.49 69.88,30.23 69.34,30.23 69.27,30.15
VCC_31334 on BOTTOM: 43.36,44.55 45.66,44.55 46.57,43.64 46.57,39.13 46.95,38.75 48.63,38.75 48.78,38.6 48.78,38.01 48.77,38 46.35,38 45.78,38.56 45.78,42.81 45.09,43.51 43.43,43.51 43.28,43.66 43.28,44.48
VCC_31334 on BOTTOM: 55.99,11.67 57.19,11.67 57.21,11.65 57.21,11.32 56.65,10.76 56.45,10.76 55.87,11.34 55.87,11.54
VDD_IN_1261 on TOP (solid shape): 31.91,16.32 31.91,15.3 31.73,15.12 30.13,15.12 29.57,15.68 29.57,16.49 31.73,16.49
VDD_IN_1261 on TOP (solid shape): 24.59,18.58 22.31,16.29 22.31,12.81 22.1,12.61 21.82,12.61 21.64,12.79 21.64,16.54 24.21,19.11 24.59,19.11
VDD_IN_1261 on BOTTOM (solid shape): 31.93,16.22 31.93,10.29 31.68,10.04 20.12,10.04 19.82,10.35 19.82,11.87 21.47,13.52 21.47,13.8 21.62,13.95 22.08,13.95 22.23,13.8 22.23,12.76 22.08,12.61 21.49,12.61 20.53,11.64 20.53,10.7 20.63,10.6 31.28,10.6 31.37,10.69 31.37,14.49 30.56,15.3 30.56,16.32 30.69,16.44 31.7,16.44
DCC_SW_1261 on TOP (solid shape): 32.26,20.1 32.26,19.19 30.92,19.19 30.1,20 29.11,20 28.68,20.43 28.68,20.66 31.7,20.66
Net_212 on TOP (solid shape): 8.27,26.02 7.76,26.02 7.76,28.01 1.78,28.01 1.78,21.52 1.27,21.52 1.27,28.52 8.27,28.52
PSW_31334 on TOP (solid shape): 39.27,36.58 38.91,36.22 37.92,36.22 37.57,36.58 37.57,38.86 39.27,38.86
PSW_31334 on TOP (solid shape): 69.39,36.91 69.39,36.83 68.71,36.14 68,36.14 67.31,36.83 67.31,38.07 68.22,38.07
PSW_31334 on TOP (solid shape): 39.27,39.45 39.27,38.38 39.22,38.33 37.59,38.33 37.57,38.35 37.57,39.45 37.8,39.67 39.04,39.67
PSW_31334 on TOP (solid shape): 45.54,43.48 45.54,42.66 46.99,41.22 46.99,41.09 45.01,41.09 44.83,40.91 44.83,40.23 44.73,40.13 44.45,40.13 43.81,40.77 43.81,41.63 44.25,42.06 44.25,43.56 45.47,43.56
PSW_31334 on BOTTOM (solid shape): 45.44,42.19 45.44,38.61 45.72,38.33 45.72,36.88 45.03,36.88 44.81,37.11 42.98,37.11 42.88,37.21 42.88,38 43.76,38.89 43.76,42.21 43.87,42.32 45.31,42.32
PSW_31334 on TOP: 68.53,21.18 68.68,21.03 69.52,21.03 69.8,21.31 69.8,23.93 68.86,24.87 68.86,25.32 67.61,25.32 67.61,24.28 68.53,23.37
PSW_31334 on TOP: 54.23,38.56 54.05,38.38 54.05,37.19 54.2,37.03 56.39,37.03 56.39,38.56
PSW_31334 on BOTTOM: 53.16,38.3 55.45,38.3 55.58,38.18 55.58,36.93 55.42,36.78 53.16,36.78
PSW_31334 on BOTTOM: 39.73,38.63 38.13,38.63 37.69,38.2 37.69,36.5 37.95,36.25 38.94,36.25 40.21,37.52 40.21,38.15
RFO_1261 on TOP (solid shape): 22.93,19.79 22.88,19.74 22.83,19.65 22.81,19.56 22.81,19.22 22.1,19.22 22.06,19.33 21.95,19.37 21.44,19.37 21.44,19.65 21.95,19.65 22.05,19.69 22.1,19.8 22.43,19.8 22.54,19.82 22.64,19.88 22.74,19.99
UNNAMED_8_CAP_I10_N1 on TOP: 46.69,16.98 46.13,16.98 46,16.85 46,14.94 46.54,14.94 46.54,16.75 46.69,16.9
UNNAMED_9_CAP_I41_N1 on TOP (solid shape): 5,13.79 5.04,13.7 5.13,13.66 5.77,13.66 5.79,13.67 5.82,13.67 6.23,13.67 6.25,13.67 6.27,13.66 6.91,13.66 6.97,13.68 7,13.73 7.31,13.73 7.31,13.32 7,13.32 6.97,13.37 6.91,13.38 6.27,13.38 6.25,13.38 6.23,13.37 5.82,13.37 5.79,13.38 5.77,13.38 5.13,13.38 5.04,13.35 5,13.26 4.67,13.26 4.67,13.79
UNNAMED_9_CAP_I56_N2 on TOP: 29.7,22.46 28.33,21.09 28.33,20.86 28.66,20.86 29.72,21.93 32.14,21.93 32.28,22.07 32.28,22.33 32.15,22.46
UNNAMED_9_CAP_I57_N1 on TOP: 32.21,22.87 29.75,22.87 28.48,21.6 28.45,21.6 28.45,22.11 29.75,23.4 32.21,23.4
UNNAMED_9_CAP_I97_N1 on TOP (solid shape): 24.08,19.29 21.75,16.95 19.13,16.95 19.13,17.84 21.24,17.84 22.23,18.83 22.74,18.83 23.52,19.62 24.08,19.62
UNNAMED_9_CAP_I126_N1 on TOP (solid shape): 9.26,22.91 9.33,22.73 9.51,22.66 9.98,22.66 10.01,22.66 10.03,22.67 10.44,22.67 10.46,22.66 10.49,22.66 11.16,22.66 11.18,22.66 11.2,22.67 11.46,22.67 11.46,22.36 11.2,22.36 11.18,22.37 11.16,22.38 10.49,22.38 10.46,22.37 10.44,22.36 10.03,22.36 10.01,22.37 9.98,22.38 9.51,22.38 9.33,22.3 9.26,22.12 9.26,21.51 8.01,21.51 8.01,23.52 9.26,23.52
UNNAMED_10_ADLTC3130V2_I172_BST1 on TOP (solid shape): 31.01,43.05 31.01,42.39 29.39,42.39 28.85,41.86 28.7,41.86 28.63,41.94 28.63,42.47 29.29,43.13 30.94,43.13
UNNAMED_10_ADLTC3130V2_I172_BST2 on TOP (solid shape): 31.01,39.57 31.01,39.04 30.99,39.01 28.75,39.01 28.63,39.14 28.63,39.62 28.68,39.67 30.91,39.67
UNNAMED_10_ADLTC3130V2_I172_PVIN on TOP (solid shape): 39.29,40.36 39.01,40.08 37.8,40.08 37.54,40.34 37.54,41.45 39.29,41.45
UNNAMED_10_ADLTC3130V2_I172_PVIN on TOP (solid shape): 31.04,46.28 31.04,43.48 30.96,43.41 29.11,43.41 28.4,42.7 28.14,42.7 28.14,46.02 28.42,46.3 31.01,46.3
UNNAMED_10_ADLTC3130V2_I172_PVIN on TOP (solid shape): 38.84,43.97 38.84,43.03 39.29,42.57 39.29,40.87 37.59,40.87 37.54,40.92 37.54,43.94 37.69,44.09 38.71,44.09
UNNAMED_10_ADLTC3130V2_I172_PVIN on TOP (solid shape): 28.35,44.7 28.35,44.2 27.56,44.2 27.51,44.15 27.51,43.97 27.89,43.59 27.89,43.08 27,43.97 27,44.73 28.32,44.73
UNNAMED_10_ADLTC3130V2_I172_PVIN on BOTTOM (solid shape): 28.93,46.82 35.39,46.82 38.76,43.46 38.76,42.16 38.63,42.04 37.57,42.04 37.44,42.16 37.44,42.42 34.56,45.3 29.76,45.3 29.26,44.81 28.3,44.81 28.14,44.96 28.14,46.38 27.71,46.81 27.53,46.81 27.33,47.02 27.33,47.12 27.53,47.32 28.44,47.32
UNNAMED_10_ADLTC3130V2_I172_SW1 on TOP (solid shape): 35.69,42.82 35.69,41.2 35.61,41.12 31.57,41.12 31.29,41.4 29.16,41.4 29.11,41.45 29.11,41.66 29.44,41.99 31.29,41.99 32.23,42.93 35.59,42.93
UNNAMED_10_ADLTC3130V2_I172_SW2 on TOP (solid shape): 35.69,39.98 35.69,38.63 34.59,37.54 29.49,37.54 28.45,38.58 28.45,38.84 28.57,38.84 28.83,38.58 31.04,38.58 31.62,39.17 31.62,39.9 31.75,40.03 35.64,40.03
UNNAMED_10_ADMAX31334_I82_VBAT on BOTTOM (solid shape): 53.2,43.22 50.25,43.22 49.49,42.46 48.4,42.46 48.25,42.61 48.25,42.81 50.18,44.74 53.2,44.74
UNNAMED_10_ADMAX31334_I82_VCC on TOP (solid shape): 46.73,45.44 46.73,42.99 47.37,42.36 47.37,41.72 47.24,41.6 47.11,41.6 45.75,42.96 45.75,43.73 44.81,44.68 44.81,45.69 44.86,45.75 46.43,45.75
UNNAMED_10_ADMAX77675_I110_IN on TOP: 66.43,20.35 66.43,17.99 65.99,17.56 65.99,17.41 66.07,17.33 66.76,17.33 67.34,17.92 67.34,19.02 67.54,19.23 70.31,19.23 70.74,19.66 70.74,20.55 70.66,20.62 66.7,20.62
UNNAMED_10_ADMAX77675_I110_LXA on TOP: 68.18,23.02 66.7,23.02 66.55,22.87 66.55,21.19 66.7,21.04 68.18,21.04 68.3,21.17 68.3,22.89
UNNAMED_10_ADMAX77675_I110_LXA on TOP: 65.43,17.43 65.43,18.86 65.74,19.16 66.09,19.16 66.2,19.06 66.2,18.07 65.69,17.56 65.69,17.41 65.66,17.38 65.49,17.38
UNNAMED_10_ADMAX77675_I110_LXA on BOTTOM: 65.69,18.09 65.84,17.94 66.2,17.94 66.63,18.37 66.63,20.25 67.42,21.04 68.2,21.04 68.33,21.17 68.33,22.89 68.18,23.05 67.42,23.05 65.69,21.32
UNNAMED_10_ADMAX77675_I110_LXB on TOP: 64.22,23.02 65.69,23.02 65.84,22.87 65.84,21.19 65.69,21.04 64.22,21.04 64.09,21.17 64.09,22.89
UNNAMED_10_ADMAX77675_I110_LXB on BOTTOM: 64.11,23.05 64.04,22.97 64.04,21.09 64.25,20.88 64.56,20.88 64.8,20.63 64.8,17.36 64.7,17.26 64.7,16.65 64.8,16.54 65.41,16.54 65.49,16.62 65.49,22.41 64.85,23.05
UNNAMED_10_ADMAX77675_I110_PVDD on TOP: 62.84,19.31 62.84,20.96 62.84,20.96 62.84,21.08 62.74,21.18 61.97,21.18 61.95,21.16 61.8,21.16 61.39,20.75 61.39,20.42 61.51,20.3 62.21,20.3 62.28,20.23 62.28,19.31
UNNAMED_10_ADMAX77675_I110_PVDD on TOP: 65.77,15.53 65.76,15.52 65.76,15.37 66.04,15.09 67.26,15.09 67.41,14.94 67.41,13.97 67.74,13.64 68.5,13.64 68.66,13.79 68.66,15.47 68.6,15.53
UNNAMED_10_ADMAX77675_I110_SBB0 on TOP: 65.07,15.65 64.95,15.65 64.67,15.37 64.67,14.94 64.21,14.48 64.21,13.72 64.39,13.54 65.84,13.54 65.99,13.69 65.99,14.73
UNNAMED_10_ADMAX77675_I110_SBB1 on TOP: 62.18,13.59 62.18,14.17 63.75,15.75 64.34,15.75 64.41,15.67 64.41,15.01 62.99,13.59
UNNAMED_10_ADMAX77675_I110_SBB2 on TOP: 63.6,16.94 62.2,16.94 62.15,16.89 62.15,16.13 62.48,15.8 63.47,15.8 64.11,16.43
UNNAMED_10_ADMAX77675_I110_SBB3 on TOP: 63.25,18.26 62.43,18.26 62.15,17.98 62.15,17.32 62.18,17.3 63.55,17.3 64.01,16.84 64.21,16.84 64.21,17.3
UNNAMED_10_CN2P_I63_N2 on TOP: 7.02,40.27 7.02,41.92 6.74,42.2 3.75,42.2 3.19,41.64 3.19,40.55 3.92,39.81 6.57,39.81
UNNAMED_10_DIOSCHOTTKY_I62_N on TOP: 12.38,41.87 12.38,40.02 12.18,39.81 10.02,39.81 9.56,40.27 9.56,41.69 9.99,42.13 12.13,42.13
UNNAMED_10_NC3PJMPR_I56_A on TOP: 13.53,41.72 13.53,38.16 12.87,37.5 11.24,37.5 11.24,35.62 13.35,35.62 17.31,39.59 17.31,41.97 13.78,41.97
VOUT_3130 on TOP (solid shape): 82.93,21.46 82.93,20.42 82.7,20.19 81.76,20.19 80.59,21.36 80.59,21.69 82.7,21.69
VOUT_3130 on TOP (solid shape): 29.31,37.34 34.85,37.34 35,37.19 35,36.12 34.82,35.94 27.64,35.94 27.64,38.84 27.81,38.84
VOUT_3130 on TOP: 80.63,40.12 80.63,37.07 80.99,36.72 81.19,36.72 81.5,37.02 81.5,37.15 82.18,37.83 82.18,38.87 80.89,40.17 80.68,40.17
VOUT_3130 on BOTTOM: 81.46,39.93 81.46,37.92 81.67,37.71 82.59,37.71 82.89,38.01 82.89,39.61 82.58,39.93
VOUT_3130 on BOTTOM: 25.7,37.39 35.05,37.39 37.77,34.67 38.46,34.67 38.46,34.11 38.25,33.91 37.16,33.91 35.18,35.89 26.12,35.89 24.88,34.65 24.88,32.55 23.91,31.58 23.91,30.57 20.56,27.22 20.56,26.71 21.44,25.83 21.4,25.79 20.31,25.79 19.6,26.5 19.6,28.23 20.74,29.38 20.74,32.12 21.68,33.06 22.9,33.06 23.36,33.52 23.36,35.04
VOUT_3130 on BOTTOM: 81.45,21.64 81.45,20.68 81.84,20.29 82.73,20.29 82.88,20.45 82.88,21.33 82.57,21.64
VREG_1261 on TOP (solid shape): 29.32,18.5 30.26,18.5 30.48,18.27 32.26,18.27 32.26,17.36 31.8,16.9 29.57,16.9 29.57,17.26 27.39,19.44 27.39,19.64 28.17,19.64

Small or netless copper shapes (teardrops, artwork): 243 on TOP, 222 on BOTTOM, 5 on L3_PWR

## Text on the board
Ref Des/Assembly Bottom: 1
Ref Des/Silkscreen Bottom: GND | MAX32670-SX-ARDZ | 08-079721 REV B Z | SECONDARY SIDE | 7 | 8
User.Comments: 6.    DO NOT TRIM EXCESS PINS FOR THE FOLLOWING LOCATIONS | B. P4 | A. P3 | D. P7 | C. P6 | 5.    SOLDER SHORT PINS BELOW: | B. JP2 (PINS 2 & 3) | A. JP1 (PINS 1 & 2) | D. JP4 (PINS 1 & 2) | C. JP3 (PINS 1 & 2) | 8.    THESE FOLLOWING PARTS ARE DNI. | WITH LEAD-FREE AND RoHS PCB ASSEMBLY STANDARDS (EU RoHS | DIRECTIVE 2002/95/EC). | 7.    1 PIN OF R156 AND C63 IS OVERLAPPING BUT C63 IS DNI. | 4.    RoHS COMPLIANCE: ASSEMBLY VENDOR SHOULD ASSURE COMPLIANCE | R99,R110,R113,R114,R117,R123,R126,R127,R128,R132,R133,R134,R136,R137,R138, | R143,R146,R148,R149,R157,R159,R161,R162,R163,R170,R171,R173 | -C13 | -R6,R11,R12,R13,R60,R63,R65,R67,R70,R71,R72,R73,R78,R79,R81,R90,R91,R94,R96,R98, | -C25,C26 | -R1,R3,R8,R9,R14,R16,R118,R119,R131 | -P2,P10 | -C65,C67 | -C63
Ref Des/Silkscreen Top: 1 | 7 | 8
PAGE_OUTLINE: B | B1 | ECR-116885 | ECR-119053(UPDATE DNI LIST ON ASSY NOTES ONLY) | (NO CHANGE ON LAYOUT) | 07DEC23 | 29JAN24 | E. REYTA | MAX32670-SX-ARDZ
DIMENSION: 2.00IN | -0.10IN | "0" | (REF) | -0.35IN | 3.15IN
User.10: L2 Internal GND | 08-      -07
User.11: L3 Internal GND | 08-      -08
User.12: FAB NOTES REVISION: 2ND NOVEMBER 2022 | 8.   IMPEDANCE REQUIREMENTS: IF NO STACKUP IS DEFINED, THE VENDOR IS ALLOWED TO ADJUST THE DIELECTRIC | 13.  PLATING SPECIFICATION: | 9.   FILLET OPTIONS TO ENHANCE RELIABILITY AT PAD JUNCTIONS WHERE SPACING PERMITS. | 10.  THIEVING: | 11.  LAYER TO LAYER REGISTRATION SHALL BE WITHIN 0.003 INCHES. | 12.  DRILL SIZES ARE FINISHED HOLE SIZES. ALL HOLES SHALL BE LOCATED WITHIN 0.005 INCHES DTP,UNLESS SPECIFIED. | 14.  SURFACE FINISH: | 15.  SOLDERMASK: | 1.   DIMENSIONS ARE IN INCHES (EXCEPT WHERE NOTED). | ALL DOCUMENTS & SPECIFICATIONS REFERRED TO BELOW SHOULD BE THE LATEST REVISIONS. | 2.  BOARD MATERIAL:(USE CHECKED ITEMS) | 3.   ALL LAMINATES & BONDING MATERIALS SHOULD BE SELECTED FROM IPC-4101 OR IPC-4103,(TG>170 DEGC TD>300 DEGC) | 4.   REFER TO IPC-6010 SERIES, CLASS 2 FOR FABRICATION. | 5.   REFER TO LAMINATION DIAGRAM FOR OVERALL BOARD THICKNESS, TOLERANCE APPLIES AFTER ALL LAMINATION AND PLATING | 6.   BOW & TWIST NOT TO EXCEED 0.0075 INCHES (0.75%) PER LINEAR INCH AND SHOULD BE MEASURED PER IPC-TM-650, METHOD 2.4.22. | 7.   ACCEPTABILITY PER ADI SPECIFICATION TST00115. | 16.  APPLY SILKSCREEN TO BOTH SIDES USING A NON-CONDUCTIVE, EPOXY BASED INK PER ARTWORK. | ( ) FILLETS ALLOWED | (X) FILLETS NOT ALLOWED | ( ) VENDOR MAY ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS MAINTAINING A MINIMUM | ( ) VENDOR MAY NOT ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS. | (X) LPI | ( ) OTHER_________ | COLOR | (X) GREEN | (X) WHITE | ( ) OTHER | HINDER PROPER SOLDER WICKING. BARREL RELIEF ON SOLDERMASK ALLOWED IN UNFILLED VIA IN PAD HOLES. | (X) REFER TO LAMINATION DIAGRAM FOR FINISHED COPPER WEIGHT/THICKNESS REQUIRMENTS | (X) IMMERSION GOLD (ENIG) 1.58-3.94 MICRO INCHES OVER 118-236 MICRO INCHES MIN. OF ELECTROLESS NICKEL PER IPC-4552 | ( ) OSP (ORGANIC SOLDERABILITY PRESERVATIVE) | ( ) IMMERSION SILVER | ( ) SOFT WIRE BONDABLE GOLD 30-50 MICRO INCHES OF SOFT WIRE | ( ) EDGE CONNECTOR FINGERS ARE TO BE PLATED WITH 100 MICRO-INCHES(.0001") OF LOW STRESS | ( ) OTHER: | THICKNESS & TRACE WIDTHS TO MEET THE IMPEDANCE REQUIREMENT. IF SPECIFIED, THE VENDOR MUST | TRACE WIDTH & SPACING THAT IMPACT THE REQUIREMENTS MUST HAVE WRITTEN APPROVAL FROM ADI. | MINIMUM BARREL PLATING OF 0.001 INCHES. PLATED HOLES SHALL NOT BE ROUGH OR IRREGULAR SO AS TO | SOLDERMASK OVER BARE COPPER OR BARE GOLD (BOTH SIDES) TO MEET IPC-SM-840. | IF PRESENT,DO NOT MODIFY SOLDERMASK DEFINED PADS (MASK OPENINGS LESS THAN COPPER PAD) WITHOUT APPROVAL. | MEET THE REQUIREMENTS LISTED IN THE IMPEDANCE TABLE. ANY ADJUSTMENT MADE TO THE DEFINED STACKUP, | PROCESSES. FINISHED THICKNESS MEASURED FROM TOP COPPER TO BOTTOM COPPER. | (X)  ISOLA 370HR OR EQUIVALENT | ( )  ISOLA-FR408HR OR EQUIVALENT | ( )  ISOLA IS410 | ( )  MEGTRON 6 | ( )  NELCO-4000-13 | ( )  ROGERS 4350B | ( ) ROGERS 3003 | ( ) ARLON 85N | ( ) EM370D | ( )  OTHER ________________________ | X | UL FLAMMABILITY RATING 94V-0. BOARD MATERIAL & CONSTRUCTION SHALL MEET THE REQUIREMENTS OF UL796/UL796F. | BONDABLE GOLD OVER 100-150 MICRO INCHES OF NICKEL | NICKEL UNDER 30 MICRO-INCHES (.0003') OF GOLD | 0.100 INCH CLEARANCE FROM ALL COPPER FEATURES, | THE STARTING COPPER WEIGHT/THICKNESS CAN VARY AS LONG AS THE FINISHED COPPER | WEIGHT/THICKNESS IS NOT LESS THAN THE SPECIFIED VALUE. | UNLESS OTHERWISE SPECIFIED | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLAINT WITH THE EU DIRECTIVE 2002/95/EC | WORKMANSHIP SHALL CONFORM TO IPC-A-600, CLASS 2. | 21.  INTENTIONAL SHORTS: | 17.  FINAL ELECTRICAL TEST TO BE PERFORMED USING PROVIDED IPC-D-356A NETLIST OR ODB++ FORMAT FILE. | 22.  PEMNUTS: | 23.  MANUFACTURER TO ETCH/STAMP WITH PERMANENT NON-CONDUCTIVE INK | ON SECONDARY SIDE UNLESS OTHERWISE SPECIFIED: | 18.  A TIME DOMAIN REFLECTOMETER REPORT (TDR) FOR EACH IMPEDANCE CONTROLLED LAYER & A CERTIFICATE | 19.  IF PRESENT, ALL BLIND/BURIED VIAS WITH AN ASPECT RATIO <1:1 TO BE PLATED SHUT WITH COPPER WHEN | 20.  FOR VIA FILL INFORMATION REFER TO DRILL CHART: | 25. PANELIZATION: | 27.  MINIMUM DESIGN LINE WIDTH IS .006 INCH. | 28.  MINIMUM DESIGN LINE SPACING IS .004 INCH. | IS ACCEPTABLE, ALL OTHER INSTANCES MUST BE REPORTED. | IF AN INTENTIONAL SHORT REPORT IS SUPPLIED AND DOES NOT MATCH THE FAB DATA THEN | THE PCB SHALL HAVE A VERIFICATION STAMP. | ( )  NON-CONDUCTIVE EPOXY FILL ALL 0.0050 INCHES AND 0.0100 INCHES DRILLED VIAS | ( )  COPPER FILL ALL 0.XXXX INCHES DRILLED VIAS | ( ) PEMNUTS TO BE INSTALLED BY FABRICATOR | ( ) PEMNUTS NOT TO BE INSTALLED BY FABRICATOR | ( ) NOT APPLICABLE | USED AS VIA-IN-PAD OR AS A STACKED VIA. BLIND/BURIED VIAS WITH AN ASPECT RATIO >1:1 TO BE FILLED | A. UL CODE-FLAMMABILITY RATING FOR THOSE APPROVED MATERIALS(IF APPLICABLE) | B. DATE CODE | C. LOT NUMBER | D. MANUFACTURER LOGO | BOARDS TO BE SHIPPED SINGULATED AFTER FABRICATION PROCESS | SMOOTHEN EDGES AND FREE FROM BURRS AFTER DEPANELIZATION PROCESS | CAN'T BE PERFORMED BECAUSE THE TRACE LENGTH IS TOO SHORT ON THE OUTER LAYERS AT THE PIN ESCAPES | ADI APPROVAL IS REQUIRED. | OF COMPLIANCE SHALL BE PROVIDED BY VENDOR AT TIME OF SHIPMENT. INSTANCES WHERE TDR TESTING | WITH NON-CONDUCTIVE EPOXY. | NOTE:CPWG=COPLANAR WAIVEGUIDE | TOOLING: | FINISH: | NOTES: | MATERIAL: | TESTING: | MISCELLANEOUS: | DIA MAX
User.16: L2 GND | 08-      -07
User.17: L3 PWR | 08-      -08
User.19: NX2016SA-32M-EXS00A-CS06465 ASSY DETAIL | #4 | #1 | SCALE:NONE | FOR Y4 | BOTTOM | TOP | #2 | #3 | CHAMFER
User.35: PER ECR-094468 | B | 28MAY20 | PD
User.37: PAGE 1 OF 5 | TOP SIDE VIEW | VIEW OF SILKSCREEN, PINS, VIAS, | ETCH AND REFERENCE INFORMATION. | TEMPLATE NOTES. | 01.COMPONENTS ARE PLACED ON THIS SIDE. | 02.CONNECTORS P1,P2.P4 & P5 ARE PLACED | ON THIS SIDE OF THE BOARD. | 03.IF THE BOARD NEEDS TO BE INCREASED | IT CAN BE INCREASED IN THE DIRECTION | OF THE ARROWS. | 04.THE BOARD IS SET-UP AS A 4 LAYER | BOARD. MAKE SURE ANY SUBSEQUENT CHANGES, | MANUAL OR AUTOMATIC, DO NOT RESULT IN | ANY UNINTENDED CONSEQUENCES. | 05.THE EXISTING ROUTING CAN BE ALTERED AS | IS ROUTED TO CLOSE THE NETS ON THE | TEMPLATE BOARD.
User.38: PAGE 2 OF 5 | BOTTTOM SIDE VIEW | VIEW OF SILKSCREEN, PINS, VIAS, | ETCH AND REFERENCE INFORMATION. | TEMPLATE NOTES. | 01.COMPONENTS ARE PLACED ON THIS SIDE. | 02.CONNECTORS P3 IS PLACED ON THIS SIDE. THE | OTHER CONNECTORS ARE SOLDERED THIS SIDE. | 03.THE TEMPLATE IS VIEWED LOOKING FROM THE | TOP SIDE OF THE BOARD. THE RESULT IS | THAT TEXT IS MIRRORED. | 04.THE BOARD IS SET-UP AS A 4 LAYER | BOARD. MAKE SURE ANY SUBSEQUENT CHANGES, | MANUAL OR AUTOMATIC, DO NOT RESULT IN | ANY UNINTENDED CONSEQUENCES.
User.39: PAGE 3 OF 5 | PCB FAB SHEET 1 | NCDRILL LEGEND, APPROPRIATE | DETAILS AND OUTLINE DIMENSION NOTES. | 01. EACH TIME THE NC DRILL LEGEND | IS RUN, THE HOLE CHART MUST BE | CHECKED TO ASSURE THE TOLERANCES | & NOTES CORRESPOND TO THE RIGHT | PADSTACKS.
User.40: PAGE 4 OF 5 | PCB FAB SHEET 2 | FABRICATION NOTES. ALTER DEPENDING ON THE | REQUIREMENTS OF THE DESIGN.
User.41: TEMPLATE REVISION HISTORY | TEMPLATE BOARDS FOR EVAL PROVIDE INFORMATION IN THE | 5-VIEW "PDF FORMAT" FOR EVAL ENGINEERING | REFERENCE; ALONG WITH EMBEDDED ALLEGRO | PROPERTIES FOR PCB DESIGN USE. | THEY MAINTAIN A SEPARATE TITLE BLOCK AND PART | NUMBER FOR REVISION TRACKING, INDEPENDENT OF | THE ACTUAL MANUFACTURED DUT-SPECIFIC BOARD | DESIGN. | TEMPLATE BOARDS DISPLAY AS "FILE VIEWS", AND | DUT-SPECIFIC APPLICATION BOARDS ARE | MANUFACTURED FROM ARTWORK "FILM VIEWS"AND NC | DATA. | AND TITLE BLOCK CONTENT IS TRACKING THE | MANUFACTURED BOARD PART NUMBER AND REV, | AND NOT THE TEMPLATE BOARD PART NUMBER AND | REV. | PAGE 5 OF 5 | MAKE SURE THE DUT-SPECIFIC BOARD INFORMATION | REV.A (20APR20) | 1. INITIAL RELEASE. | REV.B (28MAY20) PER ECR-094468 | 1. BRING FILES INTO TEMPLATE FORMAT.
User.45: 1 | FABRICATION | 09-012345-01 | A | FIGURE | SIZE | 5.0 | 10.0 | 15.0 | 25.0 | 40.0 | 45.0 | 50.0 | 60.0 | 65.0 | 125.0 | PLATED | NON-PLATED | FINISHED HOLES IN MILS | ALL UNITS ARE IN MILS | QTY | 12 | 785 | 6 | 56 | 38 | 2 | 4 | 909 | TOLERANCE/NOTES | TOTAL HOLES:
