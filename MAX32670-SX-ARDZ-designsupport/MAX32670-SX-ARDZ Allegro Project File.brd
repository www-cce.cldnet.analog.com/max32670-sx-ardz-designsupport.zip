# Allegro board MAX32670-SX-ARDZ Allegro Project File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC_3130: length 23.5
  TOP w0.279: U2.5 26.76,42.81 26.43,43.14 ; U2.6 26.26,42.34 25.98,42.62 24.28,42.62 23.38,43.52
  TOP w0.61: 26.43,43.14 26.05,43.52 C33.2 ; JP3.3 18.8,43.51 18.19,42.9 18.19,39.88 ; JP2.3 18.24,39.83 18.19,39.88 ; 18.19,39.88 18.19,36.75 18.8,36.14 JP4.3
  TOP w0.635: JP3.3 23.18,43.51 C33.2
VCC_31334: length 207.3
  TOP w0.508: v1(80.53,46) 80.53,43.7 80.15,43.32 80.15,33.36 v1(77.84,31.05) ; v1(46.69,38.25) 46.69,37.37 R2.1 ; R95.2 v1(56.57,10.72) ; v1(48.36,38.38) 48.47,38.27 R61.1 ; v1(46.24,40.6) 46.07,40.43 R5.1
  TOP w0.635: v1(12.95,42.24) JP1.2 v1(12.95,39.7) v1(12.95,38.99)
  TOP w0.762: R169.1 70.38,24.28 69.65,25.02 v1(69.65,29.36) v1(69.65,34.19) v1(69.65,34.92)
  TOP w1.524: TP3.1 15.25,48.5 34.43,48.5 37.64,45.29 42.42,45.29
  BOTTOM w0.508: R151.1 76.87,49.31 77.56,48.63 80.07,48.63 80.53,48.17 v1(80.53,46) ; R11.1 69.6,29.41 69.65,29.36 v1(69.65,29.36) v1(70.36,29.36) 76.15,29.36 v1(77.84,31.05) 82.46,31.05 84.84,28.67 84.84,15 83.16,13.32 80.45,13.32 79.46,12.33 71.59,12.33 70.64,11.38 69.44,11.38 67.75,9.69 66.56,9.69 65.33,10.92 63.91,10.92 62.73,12.1 59.63,12.1 59.32,12.41 57.95,12.41 56.57,11.03 ; R162.2 40.13,12.34 40.13,11.07 R138.2 40.44,10.87 41.12,11.56 49.45,11.56 49.57,11.44 56.15,11.44 56.57,11.03 ; v1(56.57,10.72) 56.57,11.03
  BOTTOM w0.762: 68.91,34.92 67.23,34.92 65.91,36.25 65.91,38.35 63.33,40.93 58.2,40.93 56.16,38.89 50.06,38.89 49.56,38.38 v1(48.36,38.38) 46.76,38.38 46.18,38.96 46.18,43.46 45.47,44.17 45.06,44.17 ; 68.91,34.92 v1(69.65,34.19) v1(69.65,34.92) 68.91,34.92
  BOTTOM w1.27: v1(12.95,38.99) v1(12.95,39.7) v1(12.95,42.24) v1(12.95,42.95) 12.95,44.75 TP3.1
  vias: v1(43.56,44.25) v1(44.27,44.25)
VDD_IN_1261: length 19.8
  TOP w0.203: C57.2 v1(21.92,13.67)
  TOP w0.305: L17.2 30.78,16.22 v1(30.81,16.19)
  BOTTOM w0.508: v1(21.92,12.91) 21.44,12.91 20.15,11.62 20.15,10.42 20.22,10.35 31.5,10.35 ; 31.62,14.2 31.62,11.09
  vias: v1(30.81,15.43) v1(31.58,16.19) v1(31.58,15.43)
32K_OUT_32670: length 7.5
  TOP w0.203: C26.1 40.9,16.22 41.52,15.61 Y2.2 42.35,15.61 42.98,16.24 44.05,16.24 45.54,17.73 U3.38
32KIN_32670: length 4.5
  TOP w0.203: R158.1 44.01,15.54 45.06,16.59 v1(45.42,16.59) 45.42,16.94 45.8,17.33 U3.39
  BOTTOM w0.203: R157.1 45.64,16.36 v1(45.42,16.59)
CLKOUT_31334: length 49.5
  TOP w0.203: v1(58.05,19.6) 61.42,22.96 62.36,22.96 63.6,24.21 63.6,31.83 63.31,32.12 58.84,32.12 57.68,33.27 57.68,34.21 56.95,34.95 54.86,34.95 53.94,35.88 53.51,35.88 52.15,37.24 50.62,37.24 50.15,37.71 R62.1 49.66,38.58 49.17,39.07 v1(49.17,39.22)
  TOP w0.254: U7.B3 v2(47.97,40.49)
  BOTTOM w0.203: v1(58.05,19.6) 57.82,19.37 57.82,18.43 56.58,17.18 56.58,16.5 55.83,15.75 53.31,15.75 52.7,16.36 R157.2 ; v2(47.97,40.49) 47.97,40.14 48.9,39.22 v1(49.17,39.22)
DCC_SW_1261: length 4.3
  TOP w0.305: L18.2 30.7,20.51 U4.9
DIO2_SX: length 42.2
  TOP w0.203: U4.12 27.87,22.01 28.22,22.36 28.22,23.49 R30.2 31.13,25.06 31.5,25.43 v1(31.52,25.43)
  BOTTOM w0.203: v1(31.52,25.43) 31.55,25.45 32.51,25.45 33.45,24.51 33.45,19.3 32.23,18.08 32.23,10.14 31.83,9.74 24.64,9.74 23.8,8.9 19.77,8.9 18.8,9.86 18.8,13.95 R136.1
HFXIN_32670: length 10.3
  TOP w0.203: U3.33 45.66,19.73 43.76,21.63 43.76,22.99 43.23,23.52 C24.1 40.09,23.52 39.11,24.51 Y3.3
HFXOUT_32670: length 6.6
  TOP w0.203: U3.34 45.48,19.33 43.19,21.62 C27.1 42.31,21.62 Y3.1
I2C0_SCL_32670: length 113.6
  TOP w0.203: R24.2 55.54,12.8 v1(55.58,12.76) 56.16,13.34 56.16,13.82 56.54,14.21 56.54,19.49 61.06,24 61.7,24 62.42,24.73 62.42,30.87 61.59,31.7 58.62,31.7 57.28,33.05 57.28,33.99 56.72,34.54 54.46,34.54 v1(53.68,35.32) ; R59.1 44.58,35.76 44.83,35.51 46.76,35.51 v1(46.86,35.41)
  BOTTOM w0.203: v1(55.58,12.76) 55.58,12.4 55.46,12.28 R1.2 ; P10.2 14.72,32.27 15.41,32.96 16.45,32.96 17.77,34.28 17.77,46.75 P6.10 14.86,51.94 17.12,51.94 17.5,51.56 17.5,50.32 23.32,44.5 31.34,44.5 32.35,43.5 35.55,43.5 36.83,42.21 36.83,36.78 38,35.61 38.96,35.61 40.13,36.78 44.68,36.78 45.87,35.59 46.69,35.59 v1(46.86,35.41) 47.09,35.41 47.64,35.95 49.31,35.95 50.04,35.23 52.22,35.23 52.57,35.57 53.43,35.57 v1(53.68,35.32)
I2C0_SDA_32670: length 113.3
  TOP w0.203: v1(52.82,35.01) 53.69,34.14 56.54,34.14 56.85,33.83 56.85,32.79 57.19,32.45 57.19,29.55 57.53,29.21 59.13,29.21 59.77,28.58 59.77,23.29 56.14,19.66 56.14,14.46 55.58,13.9 v1(55.58,13.57) 55.3,13.85 R25.2 ; v1(15.99,31.92) 15.99,30.39 16.31,30.07 21.26,30.07 P10.5 ; v1(46.3,34.94) 44.67,34.94 43.89,35.71 43.89,37.89 R64.2
  BOTTOM w0.203: v1(55.58,13.57) 55.43,13.42 R3.2 ; v1(15.99,31.92) 18.2,34.12 18.2,47.08 16.26,49.02 P6.9 22.96,44.09 31.14,44.09 32.14,43.09 35.37,43.09 36.4,42.06 36.4,36.63 37.92,35.1 39.24,35.1 40.51,36.37 44.5,36.37 45.94,34.94 v1(46.3,34.94) 46.55,34.7 46.96,34.7 47.82,35.55 49.09,35.55 49.81,34.82 52.6,34.82 52.77,34.99 52.79,34.99 v1(52.82,35.01)
I2C1_SCL_32670: length 136.6
  TOP w0.203: v1(71.37,33.76) 71.09,33.48 71.09,32.54 71.6,32.03 71.6,27.56 71.09,27.05 v1(71.09,26.19) 71.13,26.19 v1(72.6,24.72) 71.6,23.73 71.6,19.38 70.94,18.72 70.94,17.23 v1(71.73,16.44) 71.87,16.31 71.87,12.28 69.71,10.12 69.71,4.28 69.54,4.11 R79.2 69.02,3.33 v1(68.67,2.98) ; R40.2 v1(50.58,27.19) ; v1(48.26,34.57) 47.9,34.92 47.9,35.69 47.35,36.25 R60.1
  BOTTOM w0.203: v1(68.67,2.98) 68.14,2.45 60.73,2.45 59.11,4.08 31.63,4.08 P2.8 ; v1(71.09,26.19) 70.89,26.39 64.43,26.39 61.9,23.86 57.31,23.86 56.44,22.99 54,22.99 51.71,25.27 51.71,26.52 51.04,27.19 v1(50.58,27.19) R40.2 ; R111.1 72.78,25.46 72.6,25.28 v1(72.6,24.72) 72.93,24.39 R115.2 ; v1(48.26,34.57) 48.43,34.4 53.63,34.4 54.46,35.23 55.45,35.23 56.16,35.94 56.16,36.93 58.94,39.71 62.8,39.71 65.16,37.35 65.16,35.6 67.27,33.49 71.11,33.49 v1(71.37,33.76) ; R125.2 v1(71.73,16.44)
I2C1_SDA_32670: length 143.7
  TOP w0.203: v1(70.27,4.94) 70.27,10.05 72.29,12.07 72.29,16.95 v1(71.73,17.51) 71.4,17.84 71.4,18.59 72.6,19.79 v1(72.6,21.19) 72.03,21.76 72.03,23.57 72.36,23.9 72.62,23.9 73.18,24.46 73.18,25.1 v1(71.73,26.54) 72.21,27.03 72.21,32.59 v1(71.73,33.07) ; R63.2 43.39,35.58 44.64,34.33 47.41,34.33 v1(47.55,34.47) ; R41.2 v1(49.43,27.19) ; v1(67.35,3.01) 67.64,3.31 R78.2
  BOTTOM w0.203: v1(47.55,34.47) 48.02,34 53.96,34 54.79,34.82 55.7,34.82 56.62,35.74 56.62,36.65 59.19,39.23 62.7,39.23 64.73,37.2 64.73,35.42 67.12,33.03 71.69,33.03 v1(71.73,33.07) ; R41.2 v1(49.43,27.19) 49.43,27.29 49.93,27.79 51.1,27.79 52.17,26.72 52.17,25.48 54.25,23.39 56.13,23.39 57.01,24.27 61.74,24.27 64.32,26.85 71.42,26.85 v1(71.73,26.54) ; P2.9 33.77,4.48 59.32,4.48 60.95,2.86 67.2,2.86 v1(67.35,3.01) 68.08,3.75 69.08,3.75 v1(70.27,4.94) ; R116.2 72.83,20.13 72.6,20.35 v1(72.6,21.19) R112.1 ; R124.2 v1(71.73,17.51)
I2C2_SCL_32670: length 100.3
  TOP w0.203: R76.2 69.02,7.85 v1(69.02,7.86) ; R46.2 43.72,26.47 44.27,27.03 v1(44.27,27.19) ; v1(72.6,23.33) 73.56,22.36 73.56,18.86 v1(72.83,18.12) 73.21,17.74 73.21,11.05 v1(72.86,10.71)
  BOTTOM w0.203: R110.1 72.83,26.53 72.04,25.73 72.04,24.48 72.6,23.92 v1(72.6,23.33) ; v1(72.6,23.33) 72.13,23.33 69.49,25.97 64.7,25.97 62.13,23.4 60.03,23.4 58.6,21.97 54.01,21.97 52.58,23.4 48.17,23.4 44.39,27.19 v1(44.27,27.19) 43.99,27.47 R118.2 ; v1(72.6,23.33) R114.2 ; R126.2 72.61,17.9 v1(72.83,18.12) ; P2.10 36.14,6.86 37.77,6.86 38.25,7.34 40.36,7.34 41.08,8.06 48.42,8.06 49.59,9.23 51.6,9.23 52.77,8.06 57.08,8.06 59.73,10.71 62.12,10.71 63.94,8.88 63.94,7.61 64.53,7.02 67.65,7.02 68.49,7.86 v1(69.02,7.86) 69.43,7.86 71.84,10.27 72.45,10.27 72.86,10.68 v1(72.86,10.71)
I2C2_SDA_32670: length 108.2
  TOP w0.203: v1(72.6,22.26) 73.16,21.7 73.16,19.77 72.01,18.62 v1(72.01,18.31) 72.01,18.12 72.7,17.43 72.7,11.41 v1(72.12,10.83) ; R47.2 42.57,26.47 v1(43.28,27.18) ; v1(67.7,7.89) 67.64,7.83 R77.2
  BOTTOM w0.203: v1(72.6,22.26) 72.57,22.26 72.04,21.73 72.04,19.92 72.9,19.06 R117.2 ; v1(72.6,22.26) R113.1 ; v1(72.6,22.26) 69.32,25.54 64.88,25.54 62.31,22.97 60.21,22.97 58.75,21.51 53.83,21.51 52.37,22.97 48.01,22.97 44.54,26.44 44.02,26.44 v1(43.28,27.18) 43.08,27.18 42.85,27.41 R119.2 ; P2.7 28.5,6.84 35.39,6.84 35.83,7.29 37.59,7.29 38.05,7.75 40.16,7.75 40.9,8.49 48.27,8.49 49.44,9.66 51.76,9.66 52.95,8.47 56.85,8.47 59.52,11.14 62.27,11.14 64.35,9.06 64.35,7.89 64.81,7.43 67.25,7.43 v1(67.7,7.89) 68.24,8.42 69.41,8.42 71.82,10.83 v1(72.12,10.83) ; R123.2 71.75,18.58 v1(72.01,18.31)
MODE: length 9.7
  TOP w0.203: U2.11 26.26,39.16 26.11,39.01 22,39.01 21.44,38.46 21.44,35.51 21.23,35.31 JP4.2
NRESET_1261: length 2.6
  TOP w0.203: R32.1 26.37,26.52 R160.2 26.18,26.53 25.5,27.2 R159.2
P0_21_32670: length 53.1
  TOP w0.203: R49.2 46.32,10.19 v1(47.14,9.37) ; v1(48.31,9.37) 48.31,8.43 47.82,7.95 R68.2 ; v1(34.95,11.56) 34.52,11.56 32.67,13.4 R31.1 ; P2.2 15.96,4.51 v1(18.58,4.51)
  BOTTOM w0.203: v1(18.58,4.51) 18.82,4.26 25.9,4.26 26.35,4.71 26.35,6.49 27.11,7.25 32.87,7.25 34.67,9.05 34.67,11.28 v1(34.95,11.56) 35.08,11.43 35.08,8.31 35.59,7.8 37.49,7.8 37.85,8.15 39.97,8.15 40.73,8.92 46.66,8.92 47.12,9.37 v1(47.14,9.37) v1(48.31,9.37)
P0_23_32670: length 111.3
  TOP w0.203: v1(55.58,16.31) 55.58,16.08 54.85,15.36 R51.2 ; v1(38.86,26.42) 38.05,26.42 37.69,26.06 37.69,25.3 36.66,24.27 34.52,24.27 32.78,26.01 31.17,26.01 v1(30.84,25.68) 30.45,26.06 R30.1 ; R69.2 65.19,7.63 66,8.45 66.21,8.45 69.13,11.37 v1(69.13,12.99)
  BOTTOM w0.203: P2.3 17.26,6.98 16.72,7.51 16.72,13.91 R135.1 18.39,13.24 18.39,9.66 19.57,8.48 23.97,8.48 24.82,9.33 32.01,9.33 32.64,9.96 32.64,17.88 33.86,19.1 33.86,24.71 32.59,25.98 31.14,25.98 v1(30.84,25.68) ; v1(38.86,26.42) 39.55,25.73 41.58,25.73 43.66,23.65 43.66,23.14 44.36,22.44 45.48,22.44 46.99,20.93 50.95,20.93 v1(55.58,16.31) 56.17,16.9 56.17,17.36 57.42,18.61 57.42,19.82 57.76,20.17 58.55,20.17 59.49,19.23 59.49,17.78 60.54,16.73 60.54,14.82 61.13,14.24 65.54,14.24 66.61,13.17 68.95,13.17 v1(69.13,12.99)
P0_24_32670: length 103.4
  TOP w0.203: v1(55.58,17.35) 55.58,17.12 54.86,16.41 R52.2 ; R74.2 65.87,7.53 67.55,9.21 69.96,11.62 v1(69.96,13.02) ; R29.1 28.66,26.52 v1(28.32,26.86) 32.52,26.86 34.7,24.67 36.46,24.67 37.24,25.45 37.24,26.24 37.97,26.97 39.12,26.97 v1(39.67,26.42)
  BOTTOM w0.203: v1(69.96,13.02) 69.38,13.6 66.76,13.6 65.71,14.66 64.01,14.66 61.33,17.34 60.59,17.34 59.92,18.01 59.92,19.38 58.72,20.57 57.58,20.57 57.01,20 57.01,18.78 v1(55.58,17.35) 55.17,17.35 51.18,21.34 47.24,21.34 45.67,22.91 44.5,22.91 44.08,23.34 44.08,23.82 41.76,26.14 39.95,26.14 v1(39.67,26.42) ; v1(28.32,26.86) 28.79,26.39 32.79,26.39 34.29,24.89 34.29,18.92 33.05,17.68 33.05,9.78 32.19,8.92 25.05,8.92 23.34,7.21 21.26,7.21 P2.4
P0_25_32670: length 104.1
  TOP w0.203: R165.2 66.56,7.56 71.31,12.31 v1(71.31,14.01) ; R36.2 v1(27.51,26.86) 28.07,27.42 32.54,27.42 34.88,25.08 36.28,25.08 36.83,25.63 36.83,26.47 37.74,27.38 39.52,27.38 40.18,26.72 v1(40.34,26.72) ; R53.2 54.87,17.46 55.58,18.16 v1(55.58,18.19)
  BOTTOM w0.203: v1(27.51,26.86) 28.09,27.43 28.55,27.43 29.18,26.8 32.97,26.8 35.43,24.33 35.43,19.48 33.45,17.5 33.45,9.61 32.36,8.52 25.23,8.52 22.46,5.75 P2.5 ; v1(40.34,26.72) 40.51,26.54 41.94,26.54 43.61,24.87 44.32,24.87 47.45,21.74 51.4,21.74 54.95,18.19 v1(55.58,18.19) 56.6,19.22 56.6,20.21 57.38,20.98 58.93,20.98 60.33,19.58 60.33,18.41 61,17.74 61.51,17.74 64.19,15.06 65.89,15.06 66.94,14.01 v1(71.31,14.01)
P0_26_32670: length 161.7
  TOP w0.203: v1(82.68,28.32) 82.68,28.85 86.29,32.47 86.29,44.65 82.18,48.76 75.09,48.76 73.43,47.09 60.3,47.09 59.71,47.68 57.16,47.68 57.15,47.7 R91.1 ; v1(40.97,27.1) 40.79,27.28 40.21,27.28 39.7,27.79 37.54,27.79 36.42,26.67 36.42,25.81 36.1,25.49 35.06,25.49 32.72,27.82 27.67,27.82 v1(27.53,27.69) 27.37,27.53 R160.1 ; v1(56.67,28.73) 56.67,28.14 57.25,27.56 57.25,24.18 57.89,23.55 57.89,22 55.58,19.69 v1(55.58,19.21) 54.88,18.51 R54.2
  BOTTOM w0.203: v1(40.97,27.1) 41.96,27.1 43.61,25.45 44.32,25.45 47.62,22.15 51.64,22.15 54.58,19.21 v1(55.58,19.21) ; P2.6 24.88,6.84 26.09,8.06 32.49,8.06 33.86,9.43 33.86,17.27 35.84,19.25 35.84,24.54 33.17,27.2 29.39,27.2 28.74,27.85 27.7,27.85 v1(27.53,27.69) ; v1(56.67,28.73) 57.56,28.73 58.04,29.21 61.82,29.21 63.35,27.69 67.08,27.69 67.23,27.84 82.19,27.84 v1(82.68,28.32)
P0_27_32670: length 103.4
  TOP w0.203: R90.1 v1(53.17,46.9) ; v1(47.25,39.31) 47.25,36.97 48.31,35.92 48.31,35.38 49.3,34.39 50.34,34.39 52.11,32.63 53.61,32.63 54.29,31.94 54.29,29.86 56.7,27.45 56.7,22.86 56.32,22.49 56.32,21.25 v1(55.68,20.6) 55.68,20.37 54.87,19.56 R55.2
  BOTTOM w0.203: v1(55.68,20.6) 53.8,20.6 51.84,22.56 47.83,22.56 44.45,25.93 43.71,25.93 41.88,27.76 39.34,27.76 37.9,26.31 37.9,21.29 39.14,20.04 39.14,18.59 38.05,17.5 38.05,16.81 37.69,16.46 36.3,16.46 35.34,17.41 34.61,17.41 34.26,17.07 34.26,9.25 32.67,7.65 26.83,7.65 25.94,6.77 25.94,5.06 25.57,4.69 19.24,4.69 18.83,5.09 18.2,5.09 17.23,4.12 R132.1 ; v1(53.17,46.9) 51.37,45.1 48.91,45.1 47.25,43.44 v1(47.25,39.31)
PGOOD_3130: length 23.8
  TOP w0.203: v1(18.71,33.11) 18.86,33.26 20.89,33.26 21.09,33.46 23.71,33.46 24.78,34.53 24.78,36.93 25.43,37.58 R155.1 ; R159.1 23.98,27.2 23.57,27.61 19.66,27.61 v1(19.19,28.08)
  TOP w0.254: U2.13 27.26,38.23 26.61,37.58 R155.1
  BOTTOM w0.203: v1(19.19,28.08) 19.19,29.93 18.53,30.6 18.53,32.37 18.71,32.55 v1(18.71,33.11)
PSW_31334: length 160.4
  TOP w0.254: U7.C2 45.78,41.21
  TOP w0.508: R137.1 68.18,26.55 68.24,26.49
  TOP w0.762: v1(76.33,25.88) v1(76.33,26.59) v1(76.33,31.29) v1(76.33,32) 75.92,32.41 74.4,32.41 72.77,34.04 72.77,35.74 71.53,36.98 v1(68.24,36.98)
  TOP w1.27: 69.16,23.65 68.24,24.57 v1(68.24,36.98)
  TOP w1.524: 55.37,37.8 57.23,37.8 58.27,38.84 66.38,38.84 v1(68.24,36.98)
  L3_PWR w0.508: v1(53.35,9.46) 54.48,8.33 57.58,8.33 60.17,10.92 65.3,10.92 66.5,9.73 68.53,9.73 73.56,14.76 73.56,18.49 69.72,22.33 v1(69.39,22.33)
  BOTTOM w0.508: v1(53.35,9.46) 52.12,10.69 R166.2 ; R152.1 78.07,50.47 77.66,50.89 75.32,50.89 72.49,48.06 72.49,41.24 v1(68.24,36.98)
  BOTTOM w0.635: R167.2 81.73,25.48 81.33,25.88 77.04,25.88 ; 77.04,32 v1(76.33,31.29) v1(76.33,32) 77.04,32 ; 77.04,32 84.23,32 84.91,32.69 84.91,41.94 83.85,43 R168.2 ; 77.04,25.88 v1(76.33,26.59) v1(76.33,25.88) 77.04,25.88
  BOTTOM w1.524: 53.7,37.54 50.67,37.54 50.16,37.03 45.95,37.03 44.68,38.3 44.68,40.17 44.54,40.03 44.54,38.57 43.84,37.87 38.46,37.87
  vias: v1(38.05,37.24) v1(38.05,36.53) v1(38.76,37.24) v1(38.76,36.53) v1(44.07,40.94) v1(44.53,41.5) v1(44.58,40.41) v1(45.24,41.5) v1(54.38,38.02) v1(54.38,37.31) v1(55.09,38.02) v1(55.09,37.31)
RFI_N_1261: length 2.5
  TOP w0.279: U4.22 21.26,20.51 FL1.3
RFI_P_1261: length 2.5
  TOP w0.279: U4.21 FL1.4
RFO_1261: length 2.7
  TOP w0.279: U4.23 22.96,20.01 L19.2 22.46,19.51 FL1.1
RSTN_32670: length 172.7
  TOP w0.203: S1.2 72.99,48.27 73.88,49.16 82.41,49.16 86.7,44.87 86.7,32.3 83.24,28.83 v1(83.24,27.56) 86.64,24.15 86.64,14.1 81.98,9.43 P1.10 v1(79.53,9.43) ; U3.35 45.07,18.93 44,20 42.73,20 42.47,19.74 38.63,19.74 v1(38.28,20.09)
  BOTTOM w0.203: v1(79.53,9.43) 76.71,9.43 76.16,8.88 74.84,8.88 73.77,7.81 72.99,7.81 70.83,5.65 70.83,4.69 69.38,3.24 69.38,2.81 68.54,1.97 60.6,1.97 58.9,3.67 44.64,3.67 44.23,3.26 R75.2 ; v1(83.24,27.56) 83.08,27.41 67.44,27.41 67.28,27.25 64.01,27.25 63.43,26.68 60.66,26.68 59.38,25.4 P5.5 55.7,25.4 52.9,28.2 48.93,28.2 47.83,27.1 46.3,27.1 45.44,27.97 45.44,29.18 45.01,29.62 42.37,29.62 41.02,28.27 39.14,28.27 37.47,26.59 37.47,20.9 v1(38.28,20.09)
RUN_3130: length 4.4
  TOP w0.203: U2.4 27.26,43.24 R153.2 25.19,44.51 R161.2
SPI0_MISO_32670: length 185.9
  TOP w0.203: R20.2 50.54,9.39 49.83,8.69 v1(49.83,7.8) ; P2.12 38.28,7.59 38.28,10.11 37.01,11.38 37.01,16.56 v1(36.45,17.12) ; P8.3 60.96,42.16 57.57,45.55 v1(57.57,46.01) ; R37.2 25.53,25.85 v1(25.53,26.34)
  BOTTOM w0.203: P2.12 41.6,7.24 49.28,7.24 v1(49.83,7.8) 50.42,8.38 50.88,8.38 51.23,8.03 51.23,7.8 51.78,7.25 56.79,7.25 58.69,5.35 59.63,5.35 60.72,4.25 62.19,4.25 64.12,6.18 68.95,6.18 72.22,9.46 73.06,9.46 74.1,10.5 75.37,10.5 76.2,11.34 79.99,11.34 80.98,12.33 83.7,12.33 85.96,14.59 85.96,42.54 83.82,44.68 80.49,44.68 79.25,43.43 77.53,43.43 P8.3 ; v1(36.45,17.12) 36.25,17.32 36.25,24.74 33.38,27.61 29.57,27.61 28.92,28.25 27.26,28.25 25.53,26.52 v1(25.53,26.34) ; v1(57.57,46.01) 58.23,46.67 58.23,48.2 57.61,48.82 32.31,48.82 31.88,49.25 27.97,49.25 P6.5
SPI0_MOSI_32670: length 185.7
  TOP w0.203: P2.13 40.73,7.68 40.25,7.68 39.42,8.51 39.42,9.55 37.44,11.53 37.44,16.97 v1(37.29,17.12) ; P8.2 74.3,42.74 60.99,42.74 58.36,45.38 v1(58.36,45.99) ; v1(24.79,26.37) 24.79,26.31 24.08,25.61 R33.1 ; R21.2 51.59,9.48 50.65,8.53 v1(50.65,7.8)
  BOTTOM w0.203: v1(24.79,26.37) 24.79,26.52 26.93,28.66 29.1,28.66 29.74,28.02 34.62,28.02 36.65,25.98 36.65,17.75 v1(37.29,17.12) ; P6.4 30.1,49.66 32.05,49.66 32.49,49.23 57.89,49.23 58.76,48.35 58.76,46.39 v1(58.36,45.99) ; P2.13 43.74,6.83 49.68,6.83 v1(50.65,7.8) 51.6,6.84 56.61,6.84 58.51,4.94 59.45,4.94 60.67,3.72 62.27,3.72 64.33,5.78 69.13,5.78 72.4,9.05 73.26,9.05 74.31,10.1 75.57,10.1 76.33,10.85 80.17,10.85 81.23,11.92 83.87,11.92 86.39,14.43 86.39,42.7 83.87,45.21 79.91,45.21 79.15,45.97 78.28,45.97 77.01,44.7 P8.2
SPI0_SCK_32670: length 198.9
  TOP w0.203: P2.11 37.87,6.05 37.87,9.93 36.58,11.23 36.58,16.18 35.89,16.87 35.89,17.68 36.2,17.98 v1(37.24,17.98) ; v1(51.79,8.18) 52.65,9.03 R22.2 ; v1(56.78,46.04) 56.78,45.71 60.76,41.73 74.15,41.73 P8.4 ; R34.1 v1(22.94,26.86)
  BOTTOM w0.203: v1(22.94,26.86) 24.52,26.86 26.77,29.11 29.24,29.11 29.92,28.42 34.8,28.42 37.06,26.16 37.06,18.16 v1(37.24,17.98) ; P6.6 25.83,48.84 31.67,48.84 32.11,48.41 57.38,48.41 57.72,48.07 57.72,46.98 v1(56.78,46.04) ; P8.4 77.53,40.89 79.32,40.89 79.96,41.53 79.96,43.51 80.47,44.02 83.9,44.02 85.55,42.36 85.55,14.76 83.54,12.74 80.76,12.74 79.76,11.74 76.04,11.74 75.2,10.91 73.93,10.91 72.88,9.86 72.04,9.86 68.77,6.59 64.27,6.59 63.54,7.33 63.54,8.7 61.96,10.27 59.96,10.27 57.34,7.65 52.31,7.65 v1(51.79,8.18) 51.18,8.79 49.76,8.79 48.62,7.65 41.3,7.65 40.53,6.88 38.71,6.88 P2.11
SPI0_SS0_32670: length 147
  TOP w0.203: v1(21.8,26.85) R35.1 ; P10.13 42.66,32.07 41.38,33.35 41.38,34.29 42.75,35.66 42.75,38.96 v1(42.6,39.12) ; P6.3 32.7,49.59 34.91,49.59 37.97,46.53 v1(38.33,46.53) ; v1(59.88,49.24) 59.88,48.12 60.5,47.5 73,47.5 v1(73.24,47.74) ; v1(63.04,31.55) 63.04,24.64 61.93,23.52 61.16,23.52 56.95,19.31 56.95,13.98 56.57,13.59 56.57,12.95 55.71,12.1 54.98,12.1 54.39,11.52 54.39,10.45 54.22,10.28 R23.2
  BOTTOM w0.203: v1(21.8,26.85) 21.8,26.85 22.4,27.46 24.54,27.46 26.59,29.51 29.44,29.51 30.1,28.85 34.98,28.85 36.4,27.43 37.69,27.43 39.07,28.8 40.31,28.8 P10.13 43.79,30.02 56.01,30.02 57.63,31.65 62.94,31.65 v1(63.04,31.55) ; P6.3 32.66,49.63 59.49,49.63 v1(59.88,49.24) ; v1(73.24,47.74) 73.72,48.21 R97.1 ; v1(42.6,39.12) 42.42,38.94 40.08,38.94 39.7,39.32 39.7,42.27 39.85,42.42 39.85,45.01 v1(38.33,46.53)
SPI1_MISO_32670: length 40.4
  TOP w0.203: R42.2 48.29,27.68 v1(47.12,28.85) 46.88,29.1 40.73,29.1 40.41,29.41 39.62,29.41 v1(39.46,29.58)
  BOTTOM w0.203: v1(39.46,29.58) 38.96,30.07 32.03,30.07 31.43,30.67 31.43,32.2 30.99,32.64 27.28,32.64 25.79,31.15 P10.6 ; P5.1 57.54,29.47 47.74,29.47 v1(47.12,28.85)
SPI1_MOSI_32670: length 56.5
  TOP w0.203: R43.2 v1(47.15,27.66) 47.15,27.99 46.44,28.69 40.55,28.69 40.23,29.01 38.71,29.01 38.05,29.67 29.16,29.67 28.69,30.14 28.69,31.54 26.53,33.69 25.18,33.69 24.52,33.03 21.3,33.03 21.12,32.85 19.39,32.85 19.04,32.5 13.52,32.5 P10.1
  BOTTOM w0.203: v1(47.15,27.66) 47.73,27.66 48.73,28.66 53.46,28.66 55.41,26.7 59.85,26.7 61.08,27.94 P5.4
SPI1_SCK_32670: length 36.7
  TOP w0.203: v1(38,28.88) 38.28,28.6 40.06,28.6 40.41,28.24 45.97,28.24 v1(46.2,28.02) 46.2,27.38 46,27.18 R44.2
  BOTTOM w0.203: v1(46.2,28.02) 46.48,28.3 47.62,28.3 48.39,29.07 53.86,29.07 54.99,27.94 P5.3 ; P10.7 28.5,32.23 30.56,32.23 31.02,31.77 31.02,30.47 31.83,29.67 37.21,29.67 v1(38,28.88)
SPI1_SS0_32670: length 95.5
  TOP w0.203: v1(21.06,26.87) 21.06,26.54 20.65,26.14 R65.1 ; v1(71.62,38.42) 70.08,39.95 59.61,39.95 55.38,44.18 51.19,44.18 49.85,45.53 49.21,45.53 48.44,46.3 47.52,46.3 46.79,47.04 v1(44.96,47.04) 44.29,47.71 R82.1 ; v1(37.38,28.36) 37.54,28.19 39.88,28.19 40.28,27.79 44.53,27.79 44.86,27.45 R45.2 ; v1(40.26,41.94) 39.62,41.3 39.62,36.09 37.47,33.93 36.35,33.93 35.62,33.21 32.01,33.21 P10.8
  BOTTOM w0.203: v1(40.26,41.94) 40.26,44.91 42.39,47.04 v1(44.96,47.04) ; v1(21.06,26.87) 21.06,27 21.95,27.89 24.38,27.89 26.57,30.07 28.88,30.07 P10.8 30,31.11 30,30.48 31.22,29.26 36.8,29.26 37.38,28.69 v1(37.38,28.36) ; R96.1 74.41,42.15 71.62,39.36 v1(71.62,38.42)
SWDCLK_32670: length 51.9
  TOP w0.203: R19.2 49.48,9.76 49.28,9.55 49.28,7.52 49.56,7.24 51.94,7.24 54.8,10.1 54.8,11.24 55.26,11.7 57.24,11.7 57.71,11.23 57.71,10.68 58.04,10.35 58.86,10.35 59.59,11.07 62.64,11.07 64.15,9.56 64.15,5.7 v1(64.63,5.22) ; P1.4 v1(82.8,5.62)
  BOTTOM w0.203: v1(82.8,5.62) 82.85,5.66 R15.2 82.22,7.18 82.22,8.32 80.12,10.42 76.52,10.42 75.79,9.69 74.49,9.69 73.44,8.65 72.58,8.65 69.15,5.22 v1(64.63,5.22)
SWDCLKB_32670: length 134.9
  TOP w0.203: R48.2 44.5,12.94 v1(44.5,13.31) ; v1(65.15,28.24) 64.06,29.34 64.06,31.98 63.5,32.54 59.03,32.54 58.09,33.48 58.09,34.42 57.15,35.36 55.04,35.36 54.1,36.3 53.77,36.3 52.48,37.59 52.48,42.98 52.12,43.33 50.88,43.33 49.49,44.72 48.83,44.72 48.08,45.47 47.17,45.47 46.56,46.08 44.53,46.08 43.94,46.66 41.12,46.66 40.74,47.04 v1(38.96,47.04) 38.29,47.72 R92.1 ; R161.1 v1(24.66,46.84)
  BOTTOM w0.203: v1(38.96,47.04) 38.84,47.17 31.52,47.17 31.06,47.62 25.45,47.62 v1(24.66,46.84) ; v1(44.5,13.31) 45.16,13.97 48.06,13.97 48.97,14.88 56.44,14.88 56.68,15.13 59.07,15.13 60.78,13.41 63.65,13.41 66.71,10.35 67.6,10.35 69.22,11.96 70.33,11.96 71.3,12.93 79.25,12.93 80.21,13.89 82.91,13.89 84.28,15.27 84.28,28.42 83.26,29.44 81.66,29.44 81.03,28.8 65.71,28.8 v1(65.15,28.24)
SWDIO_32670: length 56.1
  TOP w0.203: R18.2 48.43,10.19 48.87,9.75 48.87,7.32 49.35,6.83 52.12,6.83 55.21,9.92 55.21,11.01 55.49,11.29 56.98,11.29 57.3,10.97 57.3,10.49 57.85,9.94 59.07,9.94 59.75,10.63 62.5,10.63 63.7,9.42 63.7,4.9 64.15,4.46 v1(64.63,4.46) ; P1.2 v1(82.8,4.35)
  BOTTOM w0.203: v1(64.63,4.46) 64.66,4.43 68.95,4.43 72.75,8.24 73.62,8.24 74.66,9.28 75.95,9.28 76.69,10.02 79.86,10.02 81.79,8.09 81.79,3.96 82.26,3.49 R14.2 82.84,4.32 v1(82.8,4.35)
SWDIOB_32670: length 131.3
  TOP w0.203: R93.1 41.28,47.08 44.11,47.08 44.7,46.48 46.74,46.48 47.35,45.87 48.29,45.87 49.03,45.12 49.67,45.12 51.03,43.76 52.3,43.76 52.91,43.16 52.91,37.77 53.95,36.73 54.58,36.73 v1(55.22,36.09) 57.02,36.09 58.52,34.6 58.52,33.63 59.18,32.97 63.68,32.97 64.47,32.18 64.47,29.77 v1(65.99,28.24) ; v1(43.76,13) 43.76,12.52 44.55,11.73 45.09,11.73 45.64,11.18 45.64,9.25 46.13,8.76 47.45,8.76 47.7,9.02 47.7,9.95 R50.2 ; R172.2 51.21,36.45 v1(51.36,36.3)
  BOTTOM w0.203: v1(51.36,36.3) 51.46,36.4 54.91,36.4 v1(55.22,36.09) ; v1(43.76,13) 43.76,13.44 44.7,14.38 47.88,14.38 48.79,15.29 55.98,15.29 57.47,16.78 57.82,16.78 58.36,17.31 59.22,17.31 60.03,16.5 60.03,14.74 60.96,13.82 63.83,13.82 66.87,10.78 67.45,10.78 69.04,12.37 70.13,12.37 71.09,13.34 79.08,13.34 80.04,14.3 82.74,14.3 83.87,15.43 83.87,28.25 83.08,29.03 81.89,29.03 81.1,28.24 v1(65.99,28.24)
UART0A_CTS_32670: length 83.9
  TOP w0.203: R28.2 52.86,27.83 52.02,28.68 50.22,28.68 48.8,30.09 48.8,31.77 48.34,32.23 44.48,32.23 44.01,31.76 44.01,30.7 43.31,30 42.04,30 41.31,30.72 41.31,31.51 40.56,32.26 39.67,32.26 38.57,31.15 P10.11 37.58,31.68 41.63,35.74 41.63,40.87 v1(40.89,41.61) ; R83.1 47,47.72 47.6,47.12 v1(47.6,47.04) 47.92,46.72 48.6,46.72 49.39,45.94 50.03,45.94 51.37,44.59 55.55,44.59 59.78,40.36 71.27,40.36 73.28,38.35 v1(73.41,38.35)
  BOTTOM w0.203: v1(47.6,47.04) 47.04,46.48 42.42,46.48 40.89,44.96 v1(40.89,41.61) ; v1(73.41,38.35) 77.53,38.35 P8.10
UART0A_RTS_32670: length 112.8
  TOP w0.203: v1(71.3,15.16) 71.3,16.03 70.51,16.81 70.51,18.9 71.2,19.58 71.2,25.1 70.48,25.81 70.48,27.13 71.09,27.74 71.09,31.75 70.46,32.38 70.46,34.42 v1(70.92,34.87) ; R38.2 51.72,27.17 51.15,27.75 49.04,27.75 47.27,29.51 41.75,29.51 P10.12 39.04,30.07 37.13,30.07 36.31,30.9 36.31,31.76 37.24,32.69 38,32.69 41.22,35.92 41.22,40.21 v1(40.39,41.05) ; R85.1 v1(49.95,46.9) 51.45,45.4 55.89,45.4 60.25,41.05 72.31,41.05 v1(73.43,39.93)
  BOTTOM w0.203: P8.7 77.53,45.97 75.72,45.97 75.12,45.38 75.12,41.62 v1(73.43,39.93) 72.31,38.81 72.31,37.74 70.92,36.35 v1(70.92,34.87) ; R171.2 69.44,15.29 71.17,15.29 v1(71.3,15.16) ; v1(49.95,46.9) 49.95,46.55 49.73,46.33 48.34,46.33 47.68,45.67 42.77,45.67 42.16,45.06 42.16,41.88 41.27,41 40.44,41 v1(40.39,41.05)
UART0A_RX_32670: length 180.3
  TOP w0.203: v1(22.67,46.72) 21.5,45.55 v1(19.55,45.55) ; R89.1 v1(55.31,46.91) 55.46,47.07 58.88,47.07 61.98,43.97 70.92,43.97 75.29,48.34 77.34,48.34 77.53,48.15 77.53,45.97 P8.8 78.8,45.07 79.35,45.62 79.35,46.25 80.92,47.83 82.52,47.83 85.86,44.5 85.86,32.62 82.12,28.88 82.12,27.86 86.19,23.8 86.19,14.28 82.08,10.17 79.43,10.17 78.9,9.64 78.9,8.53 79.26,8.16 P1.8 ; v1(25.67,32.66) 25.22,32.22 21.81,32.22 20.74,31.15 P10.4 ; v1(42.82,34.06) 42.82,33.5 43.26,33.07 49.91,33.07 51.34,31.64 51.34,30.52 54.81,27.05 54.81,26.73 R26.2
  BOTTOM w0.203: v1(55.31,46.91) 54.22,48.01 31.93,48.01 31.5,48.44 24.38,48.44 v1(22.67,46.72) ; v1(25.67,32.66) 26.45,33.45 39.73,33.45 40.87,34.59 42.19,34.59 42.72,34.06 v1(42.82,34.06) ; v1(19.55,45.55) 19.55,44.34 19.34,44.13 19.34,33.29 19.8,32.83 P10.4
UART0A_TX_32670: length 184.7
  TOP w0.203: v1(18.86,45) 21.98,45 v1(23.13,46.14) ; R88.1 v1(54.24,46.9) 54.81,46.33 55.7,46.33 56.01,46.63 58.72,46.63 61.98,43.38 73.08,43.38 75.67,45.97 76.68,45.97 77.53,45.13 77.53,43.43 P8.9 79.55,42.92 79.55,43.64 79.88,43.97 79.88,46.15 81.15,47.42 82.32,47.42 85.39,44.35 85.39,32.74 81.71,29.06 81.71,27.64 85.75,23.59 85.75,14.46 81.89,10.59 79.22,10.59 78.46,9.84 78.46,8.11 79.68,6.89 P1.6 ; v1(26.48,32.68) 25.88,33.27 25.37,33.27 24.73,32.63 21.58,32.63 21.32,32.37 19.5,32.37 18.28,31.15 P10.3 ; v1(41.94,34.03) 41.94,33.53 42.82,32.64 48.64,32.64 49.21,32.07 49.21,30.34 50.39,29.16 52.12,29.16 54,27.28 R27.2
  BOTTOM w0.203: v1(23.13,46.14) 25.02,48.03 31.29,48.03 31.72,47.6 53.54,47.6 v1(54.24,46.9) ; v1(41.94,34.03) 41.79,34.03 41.78,34.04 40.89,34.04 39.9,33.05 26.85,33.05 v1(26.48,32.68) ; v1(18.86,45) 18.86,34.2 17.26,32.6 P10.3
UART1A_CTS_32670: length 41.9
  TOP w0.203: R84.1 48.86,47.27 v1(49.21,46.91) ; v1(55.24,24.54) 55.24,23.18 R58.2 ; v1(41.61,42.14) 41.61,41.48 42.04,41.05 42.04,35.56 40.97,34.49 40.97,32.87 v1(41.35,32.49) ; v1(52.25,27.53) 51.56,28.22 49.28,28.22 47.57,29.92 46.43,29.92 P10.14
  BOTTOM w0.203: v1(41.35,32.49) 43.86,32.49 P10.14 ; v1(49.21,46.91) 49.03,46.74 48.16,46.74 47.5,46.08 42.6,46.08 41.61,45.09 v1(41.61,42.14) ; v1(55.24,24.54) v1(52.25,27.53)
UART1A_RX_32670: length 119.5
  TOP w0.203: v1(73.93,30.61) 73.93,26.1 74.45,25.58 74.45,18.44 74.19,18.19 74.19,15.44 75.3,14.34 75.3,8.29 v1(75.55,8.04) ; R56.2 54.85,20.61 55.88,21.64 55.88,22.63 56.29,23.04 56.29,27.22 53.88,29.63 53.88,31.71 53.38,32.22 51.93,32.22 50.24,33.91 44.18,33.91 v1(44.02,34.07) ; P10.10 36.98,33.1 37.8,33.1 40.61,35.92 v1(40.61,39.5) ; R87.1 v1(52.11,46.9)
  BOTTOM w0.203: R102.1 75.98,7.61 v1(75.55,8.04) ; v1(73.93,30.61) 73.38,30.06 66.84,30.06 64.68,32.22 57.57,32.22 56.77,33.02 55.79,33.02 54.99,32.22 45.87,32.22 v1(44.02,34.07) 44.02,33.48 43.6,33.06 41.08,33.06 40.26,32.23 36.12,32.23 P10.10 ; v1(52.11,46.9) 50.72,45.52 48.72,45.52 48.06,44.86 43.23,44.86 42.98,44.6 42.98,41.53 41.17,39.73 40.84,39.73 v1(40.61,39.5)
UART1A_TX_32670: length 122.3
  TOP w0.203: R57.2 54.86,21.67 55.42,22.22 55.42,22.76 55.88,23.22 55.88,27 54.7,28.18 54.27,28.18 51.75,30.7 51.75,31.82 50.06,33.5 43.79,33.5 43.46,33.83 43.46,34.54 v1(43.54,34.62) ; v1(72.97,30.62) 72.97,26.31 74.04,25.25 74.04,18.67 73.71,18.34 73.71,15.27 74.84,14.14 74.84,7.91 v1(74.79,7.86) ; v1(40.26,40.31) 40.26,40.23 40.06,40.03 40.06,35.94 37.62,33.5 36.65,33.5 35.73,32.58 33.92,32.58 P10.9 ; R86.1 v1(51.04,46.9)
  BOTTOM w0.203: v1(72.97,30.62) 66.87,30.62 64.86,32.63 57.8,32.63 57,33.43 55.55,33.43 54.75,32.63 46.27,32.63 44.16,34.73 43.65,34.73 v1(43.54,34.62) 43.46,34.54 43.46,33.68 43.24,33.46 40.91,33.46 40.08,32.64 33.98,32.64 P10.9 ; v1(51.04,46.9) 50.06,45.92 48.51,45.92 47.85,45.26 42.95,45.26 42.57,44.88 42.57,41.71 41.27,40.41 40.36,40.41 v1(40.26,40.31) ; v1(74.79,7.86) 74.79,7.68 74.92,7.56 R103.1
UNNAMED_6_CN6P_I5_N1: length 5.9
  TOP w0.203: P3.1 45.72,3.91 46.47,4.66 46.47,6.52 46.02,6.97 R68.1
UNNAMED_6_CN6P_I5_N2: length 20.4
  TOP w0.203: P3.2 50.39,4.67 56.79,4.67 57.09,4.97 59.65,4.97 60.72,3.9 65.01,3.9 65.19,4.08 R69.1
UNNAMED_6_CN6P_I5_N3: length 16.6
  TOP w0.203: R74.1 65.26,3.49 60.46,3.49 59.4,4.56 57.26,4.56 56.97,4.27 52.53,4.27 P3.3
UNNAMED_6_CN6P_I5_N4: length 17
  TOP w0.203: R165.1 66.56,3.64 66,3.09 60.29,3.09 59.23,4.14 57.56,4.14 57.28,3.86 54.66,3.86 P3.4
UNNAMED_6_CN6P_I5_N5: length 15.5
  TOP w0.203: R77.1 R78.1 67.08,5.11 66.97,4.99 66.97,3.47 66.18,2.68 60.11,2.68 59.1,3.69 57.82,3.69 57.48,3.35 56.69,3.35 P3.5
UNNAMED_6_CN6P_I5_N6: length 13.9
  TOP w0.203: R76.1 R79.1 68.48,5.11 68.34,4.97 68.34,3.67 68.06,3.39 68.06,2.86 67.44,2.24 58.72,2.24 P3.6
UNNAMED_6_CN6P_I101_N2: length 3.1
  BOTTOM w0.508: R11.2 R10.2 P5.2
UNNAMED_6_CN8PA_I2_N3: length 15.4
  BOTTOM w0.203: R75.1 42.05,3.26 41.64,3.67 29.09,3.67 27.96,2.54 P4.3
UNNAMED_6_CN8PA_I2_N4: length 12
  TOP w0.508: v1(37.31,8.59) 37.31,7.62 36.68,6.99 34.42,6.99 33.77,6.33 33.77,4.91 33.12,4.27 32.21,4.27 P4.4
  BOTTOM w0.508: v1(37.31,8.59) 37.62,8.89 E1.1
UNNAMED_6_CN8PA_I2_N5: length 15.7
  TOP w0.508: P4.5 33.68,2.54 35,3.86 39.09,3.86 39.56,4.33 40.78,4.33 41.39,4.94 41.39,6.21 40.63,6.97 39.99,6.97 38.84,8.13 v1(38.84,8.71)
  BOTTOM w0.508: v1(38.84,8.71) 39.14,9.02 E9.1
UNNAMED_6_CN8PA_I2_N8: length 10.7
  TOP w0.508: P4.8 42.28,4.18 43.12,4.18 43.93,4.99 43.93,6.44 42.98,7.39 C39.1 43.71,8.17 E2.1
UNNAMED_6_CN8PA_I132_N1: length 4
  TOP w0.203: P7.1 56.38,48.76 R91.2 R89.2
UNNAMED_6_CN8PA_I132_N2: length 3.8
  TOP w0.203: R90.2 R88.2 54.24,49.16 P7.2
UNNAMED_6_CN8PA_I132_N3: length 2.6
  TOP w0.203: R87.2 52.11,49.57 P7.3
UNNAMED_6_CN8PA_I132_N4: length 2.2
  TOP w0.203: R86.2 51.04,50.56 P7.4
UNNAMED_6_CN8PA_I132_N5: length 2.9
  TOP w0.203: R85.2 49.95,49.34 49.42,49.87 49.19,49.87 P7.5
UNNAMED_6_CN8PA_I132_N6: length 4
  TOP w0.203: R84.2 47.99,49.57 46.95,49.57 P7.6
UNNAMED_6_CN8PA_I132_N7: length 3.3
  TOP w0.203: R83.2 43.57,50.8 P7.7
UNNAMED_6_CN8PA_I132_N8: length 4.3
  TOP w0.203: P7.8 41.85,49.59 43.24,49.59 R82.2
UNNAMED_6_CN8PODDEVEN_I6_N1: length 3.6
  BOTTOM w0.203: P9.1 76.05,23.88 74.46,25.46 R111.2 R110.2
UNNAMED_6_CN8PODDEVEN_I6_N2: length 6.2
  BOTTOM w0.203: R115.1 R114.1 74.46,23.33 75.05,22.74 77.66,22.74 P9.2
UNNAMED_6_CN8PODDEVEN_I6_N3: length 3.3
  BOTTOM w0.203: R112.2 R113.2 75.33,22.26 P9.3
UNNAMED_6_CN8PODDEVEN_I6_N4: length 6
  BOTTOM w0.203: P9.4 77.58,20.13 R116.1 R117.1
UNNAMED_6_CN8PODDEVEN_I6_N7: length 6.6
  BOTTOM w0.635: E3.1 80.72,16.29 C41.1 P9.8 P9.7
UNNAMED_6_CN10P_I39_N1: length 2.8
  TOP w0.508: P1.1 v1(86.77,4.35)
  BOTTOM w0.508: v1(86.77,4.35) 86.57,4.55 R175.2
UNNAMED_6_CN10P_I131_N1: length 4.9
  TOP w0.203: R93.2 39.97,49.39 37.99,49.39 P6.1
UNNAMED_6_CN10P_I131_N2: length 4.9
  TOP w0.203: R92.2 36.5,48.72 35.14,50.08 34.76,50.08 P6.2
UNNAMED_6_CN12PV3_I7_P1: length 2.8
  BOTTOM w0.203: P8.1 76.23,47.21 R97.2 R96.2
UNNAMED_6_CN12PV3_I7_VCC1: length 6.6
  BOTTOM w0.635: P8.6 P8.12 C40.1 80.73,34.58 E4.1
UNNAMED_6_CN18P_I78_N1: length 5.2
  BOTTOM w0.203: P2.1 13.17,4.76 13.17,4.39 R130.2 R131.2 15.05,3.57 R132.2
UNNAMED_6_CN18P_I79_N18: length 3.2
  TOP w0.508: R144.1 R98.1 55.2,31.31 P10.18
UNNAMED_6_FERRITE_I116_N2: length 7.6
  TOP w0.508: v1(44.96,10.69) 44.96,9.94 E2.2
  BOTTOM w0.508: R166.1 v1(44.96,10.69) 44.43,10.17 R127.1 44.39,9.58 R13.1 R12.1 40.61,9.58 R138.1
UNNAMED_6_FERRITE_I117_N2: length 3.5
  BOTTOM w0.508: R143.1 35.66,11.19 R177.1 36.01,11.34 E1.2
UNNAMED_6_FERRITE_I118_N2: length 4.8
  BOTTOM w0.635: R167.1 R72.1 R73.1 R134.1 80.73,19.96 E3.2
UNNAMED_6_FERRITE_I121_N2: length 4.8
  BOTTOM w0.635: E4.2 80.74,38.25 R133.1 R71.1 R70.1 R168.1
UNNAMED_6_FERRITE_I126_N2: length 3.5
  BOTTOM w0.508: R164.1 R163.1 38.8,12.58 R162.1 38.84,11.64 E9.2
UNNAMED_6_RES_I73_N1: length 7.2
  BOTTOM w0.381: R81.1 20.01,3.77 24.17,3.77 P4.2
  BOTTOM w0.508: R81.1 R80.1
UNNAMED_6_RES_I76_N1: length 3.3
  TOP w0.508: P2.18 55.43,5.82 R94.1 R95.1
UNNAMED_6_RES_I103_N2: length 5
  BOTTOM w0.508: R14.1 R128.2 84.83,3.49 R129.2 R15.1
UNNAMED_8_CAP_I10_N1: length 2.7
  TOP w0.508: C23.1 C22.1 v1(46.27,13.26)
  BOTTOM w0.508: R101.1 v1(46.27,13.26)
UNNAMED_8_CAP_I11_N2: length 4.9
  TOP w0.229: U3.37 44.97,18.13 44.51,17.67 C21.2
  TOP w0.508: C21.2 C20.2 41.85,17.67 E5.2
UNNAMED_8_CAP_I44_N1: length 4.6
  TOP w0.203: R158.2 42.42,13.11 Y2.1 41.48,12.68 C25.1
UNNAMED_8_CAP_I54_N1: length 2.5
  TOP w0.203: U3.32 45.98,20.13 45.57,20.53 45.57,21.4 C19.1
UNNAMED_8_CAP_I89_N1: length 5.2
  TOP w0.508: E5.1 v1(40.14,18.8)
  BOTTOM w0.508: v1(40.14,18.8) C42.1 40.14,16.1 R99.2 R100.2
UNNAMED_8_DIOLED_I64_P: length 1.6
  TOP w0.508: R108.2 77.45,4.1 DS1.A
UNNAMED_8_DIOLED_I75_P: length 1.6
  TOP w0.508: DS2.A 72.7,4.1 R109.2
UNNAMED_8_ICMAX3267X_I1_P0: length 5.4
  TOP w0.203: U3.10 50.65,16.07 52.3,14.42 52.3,13.36 52.86,12.8 R24.1
UNNAMED_8_ICMAX3267X_I1_P0_1: length 5.8
  TOP w0.203: U3.6 49.05,15.07 49.48,14.64 49.48,12.27 49.78,11.96 49.94,11.96 50.54,11.36 R20.1
UNNAMED_8_ICMAX3267X_I1_P0_2: length 5.4
  TOP w0.203: U3.5 48.65,14.81 49.02,14.44 49.02,11.84 49.48,11.38 R19.1
UNNAMED_8_ICMAX3267X_I1_P0_3: length 5.3
  TOP w0.203: U3.4 48.25,14.58 48.59,14.24 48.59,11.96 48.43,11.8 R18.1
UNNAMED_8_ICMAX3267X_I1_P0_4: length 6.5
  TOP w0.203: U3.9 50.25,15.81 51.77,14.29 51.77,13.28 53.7,11.35 R23.1
UNNAMED_8_ICMAX3267X_I1_P0_5: length 6.2
  TOP w0.203: R22.1 52.65,11.36 51.31,12.7 51.31,14.14 49.85,15.6 U3.8
UNNAMED_8_ICMAX3267X_I1_P0_6: length 5.9
  TOP w0.203: U3.7 49.45,15.31 50.77,13.98 50.77,12.17 51.59,11.35 R21.1
UNNAMED_8_ICMAX3267X_I1_P0_7: length 4.7
  TOP w0.203: U3.27 48.25,23.19 47.15,24.29 R43.1
UNNAMED_8_ICMAX3267X_I1_P0_8: length 4.7
  TOP w0.203: R40.1 49.89,24.71 49.89,22.59 49.45,22.15 U3.24
UNNAMED_8_ICMAX3267X_I1_P0_9: length 5
  TOP w0.203: U3.23 49.85,21.96 51.72,23.83 R38.1
UNNAMED_8_ICMAX3267X_I1_P0_10: length 5.3
  TOP w0.203: U3.22 50.25,21.75 52.86,24.37 R28.1
UNNAMED_8_ICMAX3267X_I1_P0_11: length 4.6
  TOP w0.203: R25.1 52.9,14.73 52.63,14.73 52.04,15.32 52.04,16.66 51.77,16.93 U3.11
UNNAMED_8_ICMAX3267X_I1_P0_12: length 6.6
  TOP w0.203: R26.1 52.15,22.39 52.15,21.16 51.52,20.53 U3.20
UNNAMED_8_ICMAX3267X_I1_P0_13: length 4.4
  TOP w0.203: U3.26 48.65,23.4 48.29,23.76 R42.1
UNNAMED_8_ICMAX3267X_I1_P0_14: length 5.7
  TOP w0.203: U3.21 50.65,21.57 54,24.93 R27.1
UNNAMED_8_ICMAX3267X_I1_P0_15: length 4.4
  TOP w0.203: U3.25 49.05,22.54 49.43,22.92 R41.1
UNNAMED_8_ICMAX3267X_I1_P0_16: length 3.7
  TOP w0.203: U3.18 51.94,19.73 53.09,20.88 53.09,21.49 53.26,21.67 R57.1
UNNAMED_8_ICMAX3267X_I1_P0_17: length 3.1
  TOP w0.203: R52.1 53.7,16.41 52.37,17.73 U3.13
UNNAMED_8_ICMAX3267X_I1_P0_18: length 7.3
  TOP w0.203: R47.1 42.57,25.36 43.59,24.34 44.73,24.34 45.98,23.1 45.98,20.74 46.18,20.53 U3.31
UNNAMED_8_ICMAX3267X_I1_P0_19: length 4.7
  TOP w0.203: R48.1 46.63,12.42 47.05,12.83 U3.1
UNNAMED_8_ICMAX3267X_I1_P0_20: length 5.7
  TOP w0.203: R49.1 46.32,11.35 47.68,12.7 47.68,13.78 47.45,14.01 U3.2
UNNAMED_8_ICMAX3267X_I1_P0_21: length 5.5
  TOP w0.203: R50.1 47.38,11.36 48.13,12.12 48.13,14.01 47.85,14.29 U3.3
UNNAMED_8_ICMAX3267X_I1_P0_22: length 3.6
  TOP w0.203: R51.1 53.71,15.36 52.55,16.51 52.55,16.89 52.11,17.33 U3.12
UNNAMED_8_ICMAX3267X_I1_P0_23: length 2.5
  TOP w0.203: U3.15 53.77,18.53 R54.1
UNNAMED_8_ICMAX3267X_I1_P0_24: length 3.1
  TOP w0.203: R56.1 53.64,20.47 53.26,20.47 52.12,19.33 U3.17
UNNAMED_8_ICMAX3267X_I1_P0_25: length 2.8
  TOP w0.203: R55.1 52.98,19.56 52.35,18.93 U3.16
UNNAMED_8_ICMAX3267X_I1_P0_26: length 2.8
  TOP w0.203: U3.14 52.58,18.13 52.69,18.02 53.15,18.02 53.71,17.46 R53.1
UNNAMED_8_ICMAX3267X_I1_P0_27: length 4.3
  TOP w0.203: U3.19 51.75,20.13 52.66,21.04 52.66,22.31 53.07,22.72 R58.1
UNNAMED_8_ICMAX3267X_I1_P0_28: length 6
  TOP w0.203: R46.1 44.36,24.75 44.91,24.75 47.05,22.61 U3.30
UNNAMED_8_ICMAX3267X_I1_P0_29: length 5.3
  TOP w0.203: U3.29 47.45,22.8 R45.1
UNNAMED_8_ICMAX3267X_I1_P0_30: length 5
  TOP w0.203: R44.1 46,24.82 47.85,22.98 U3.28
UNNAMED_8_RES_I3_N2: length 7.1
  TOP w0.508: v1(68.36,51.8) 68.22,51.66 S1.1
  BOTTOM w0.508: R16.2 73.26,51.59 R17.1 72.06,51.8 v1(68.36,51.8)
UNNAMED_8_RES_I65_N1: length 1.6
  TOP w0.508: v1(77.98,5.11) 77.99,5.1 R108.1
  BOTTOM w0.508: Q1.3 v1(77.98,5.11)
UNNAMED_8_RES_I66_N2: length 10.5
  BOTTOM w0.203: R102.2 75.98,5.55 75.78,5.35 74.16,5.35 73.94,5.13 73.94,3.86 74.08,3.72 R105.1 R104.2 75.43,2.76 75.62,2.95 75.62,3.56 75.77,3.72 77.49,3.72 78.17,3.03 Q1.1
UNNAMED_8_RES_I70_N2: length 11.3
  BOTTOM w0.203: Q2.1 73.42,3.03 72.74,3.71 71.13,3.71 70.17,2.75 R106.2 70.09,3.37 71.26,4.53 71.26,5.4 71.9,6.04 R107.1 R103.2
UNNAMED_8_RES_I72_N1: length 1.6
  TOP w0.508: v1(73.23,5.11) 73.24,5.1 R109.1
  BOTTOM w0.508: Q2.3 v1(73.23,5.11)
UNNAMED_8_RES_I78_N1: length 26.6
  L3_PWR w0.508: v1(50.58,24.42) 52.96,22.03 v1(52.96,13.54)
  BOTTOM w0.508: v1(50.58,24.42) R8.1 R9.1 47.13,25.39 44.88,27.64 44.88,28.73 44.64,28.97 R118.1 R119.1 ; R6.2 R7.2 52.85,13.42 v1(52.96,13.54) 53.08,13.42 R3.1 R1.1
UNNAMED_9_CAP_I41_N1: length 4.7
  TOP w0.279: J4.1 C67.1 L22.2
UNNAMED_9_CAP_I56_N2: length 3.8
  TOP w0.305: C58.2 29.76,22.2 28.57,21.01 U4.10
  BOTTOM w0.508: v1(32.11,22.2) 32.04,22.14 E6.2
UNNAMED_9_CAP_I57_N1: length 3
  TOP w0.305: U4.11 28.19,21.51 29.81,23.13 C59.1
UNNAMED_9_CAP_I93_N1: length 2.7
  TOP w0.203: U5.6 v1(18.35,19.51)
  BOTTOM w0.203: v1(18.35,19.51) 18.35,19.51 C62.1 18.34,18.46 R39.2
UNNAMED_9_CAP_I100_N2: length 3.4
  TOP w0.254: U5.4 v1(18.35,21.51)
  BOTTOM w0.508: v1(18.35,21.51) 18.39,21.56 C28.2 19.65,22.99 E7.2
UNNAMED_9_CAP_I108_N1: length 11.4
  TOP w0.279: C63.1 10.99,14.51 10.5,14.02 arc(9.95,13.65) 9.3,13.52 C65.1 L22.1
UNNAMED_9_CAP_I108_N2: length 1.4
  TOP w0.254: 17.96,20.51 U5.5
  TOP w0.279: R156.1 17.96,20.51
UNNAMED_9_CAP_I126_N1: length 2.7
  TOP w0.279: FL2.1 C66.1 11.29,22.52
UNNAMED_9_CAP_I130_N2: length 4.7
  BOTTOM w0.508: R145.2 R146.2 C43.2 29.16,23.74 E6.1
UNNAMED_9_FERRITE_I118_N1: length 5.1
  BOTTOM w0.508: R148.2 R147.2 22.09,25.05 C44.1 21.64,24.6 E7.1
UNNAMED_9_FLTRBP10P_I89_SWRFI: length 1.2
  TOP w0.254: U5.3 18.85,21.01
  TOP w0.279: 18.85,21.01 FL1.6
UNNAMED_9_FLTRBP10P_I89_SWRFO: length 1.2
  TOP w0.254: U5.1 18.85,20.01
  TOP w0.279: 18.85,20.01 FL1.8
UNNAMED_9_ICSX126X_I1_BUSY: length 2.8
  TOP w0.203: U4.14 26.48,23.49 27.1,24.1 27.1,24.65 R36.1
UNNAMED_9_ICSX126X_I1_DIO1: length 3
  TOP w0.203: R29.2 26.98,23.39 U4.13
UNNAMED_9_ICSX126X_I1_DIO3: length 6.1
  TOP w0.203: U4.6 26.98,18.58 27.19,18.37 28.02,18.37 29.16,17.23 29.16,15.17 R31.2
UNNAMED_9_ICSX126X_I1_MISO: length 2
  TOP w0.203: R37.1 25.58,24.2 25.58,23.37 25.48,23.27 U4.16
UNNAMED_9_ICSX126X_I1_MOSI: length 2.2
  TOP w0.203: R33.2 24.08,24.51 24.98,23.61 U4.17
UNNAMED_9_ICSX126X_I1_NRESET: length 2
  TOP w0.203: R32.2 26.37,24.49 25.98,24.1 U4.15
UNNAMED_9_ICSX126X_I1_NSS: length 5.1
  TOP w0.203: R65.2 R35.2 23.27,23.59 23.27,22.34 23.6,22.01 U4.19
UNNAMED_9_ICSX126X_I1_SCK: length 3
  TOP w0.203: U4.18 24.48,22.99 23.34,24.13 23.34,24.66 R34.2
UNNAMED_9_IND_I127_N2: length 5.1
  TOP w0.279: R156.2 16.25,21.25 15.76,21.74 arc(14.9,22.32) 13.89,22.52 L20.2 11.93,22.52
UNNAMED_9_RES_I105_N2: length 2.1
  BOTTOM w0.203: R39.1 R136.2 R135.2
UNNAMED_10_ADLTC3130V2_I172_PVIN: length 17.6
  TOP w0.279: C32.2 27.25,43.97 27.76,43.46 U2.3 ; U2.2 28.26,44.9 v1(28.42,45.06)
  TOP w0.508: R153.1 v1(25.98,47.07)
  BOTTOM w0.508: v1(25.98,47.07) 27.84,47.07 v1(29.13,45.77)
  BOTTOM w1.524: 30.57,46.06 35.06,46.06 37.29,43.84
  vias: v1(28.42,45.77) v1(29.13,45.06) v1(37.8,43.03) v1(37.8,42.32) v1(38.51,43.03) v1(38.51,42.32)
UNNAMED_10_ADLTC3130V2_I172_SW2: length 3.1
  TOP w0.279: U2.15 28.26,38.98 28.95,38.29 C34.2
UNNAMED_10_ADMAX31334_I82_DIN: length 5.9
  TOP w0.203: U7.B4 47.75,39.75 47.93,39.57 47.93,39.17 47.8,39.04 47.8,37.01 48.77,36.04 48.77,35.56 48.95,35.38 R4.2
UNNAMED_10_ADMAX31334_I82_INTAN: length 4.3
  TOP w0.203: R172.1 49.46,37.51 R61.2 49.47,38.08 48.62,38.94 48.62,39.47 48.25,39.84 U7.A4
UNNAMED_10_ADMAX31334_I82_SCL: length 5.7
  TOP w0.203: U7.C4 47.25,40.11 46.1,38.96 46.1,37.97 45.63,37.5 R2.2 ; R2.2 44.58,37.31 R59.2 ; R2.2 R60.2
UNNAMED_10_ADMAX31334_I82_SDA: length 4.5
  TOP w0.203: R63.1 44.43,39.43 R5.2 ; R5.2 45.94,39.43 46.79,40.28 46.79,40.46 47.04,40.71 U7.C3 ; R5.2 45.41,38.41 R64.1
UNNAMED_10_ADMAX31334_I82_VBAT: length 15.3
  TOP w0.203: U7.A1 48.25,42.46 v1(48.5,42.71)
  TOP w0.508: v1(48.5,42.71) v1(49.01,43.22) v1(49.52,43.73)
  BOTTOM w1.524: 51.37,43.98 62.04,43.98 C14.P
UNNAMED_10_ADMAX31334_I82_X1: length 2.5
  TOP w0.203: U7.A3 49.01,40.71 49.51,40.22 Y1.2
UNNAMED_10_ADMAX31334_I82_X2: length 2.5
  TOP w0.203: Y1.1 49.51,41.71 49.01,41.21 U7.A2
UNNAMED_10_ADMAX77675_I110_BST: length 8.2
  TOP w0.254: U1.B3 v2(64.84,16.23)
  TOP w0.508: C1.2 62.31,22.1 v1(61.72,21.51)
  BOTTOM w0.254: v2(64.84,16.23) 64.67,16.23 63.67,17.23 63.67,19.79 61.94,21.51 v1(61.72,21.51)
UNNAMED_10_ADMAX77675_I110_IN: length 4.4
  TOP w0.254: U1.D1 66.49,17.45 66.87,17.83 C29.2
  TOP w0.508: 68.08,20.35 68.07,20.36 67.35,20.36 C29.2
UNNAMED_10_ADMAX77675_I110_LXA: length 1
  TOP w0.254: U1.D2 65.56,17.89 65.87,18.2 v1(65.94,18.2)
  vias: v1(65.94,18.91) v1(68.05,22.77) v1(68.05,22.03) v1(68.05,21.29)
UNNAMED_10_ADMAX77675_I110_LXB: length 2
  TOP w0.254: U1.C3 v2(64.84,17.17) ; U1.C3 v2(65.28,16.73) ; U1.C3 v2(65.28,17.17) ; U1.C3 v2(64.84,16.73)
  TOP w0.508: C1.1 64.28,22.1 v1(64.34,22.03)
  vias: v1(64.34,22.77) v1(64.34,21.29)
UNNAMED_10_ADMAX77675_I110_NIRQ: length 3.8
  TOP w0.254: U1.B2 v2(65.78,16.23)
  BOTTOM w0.203: R171.1 67.44,15.27 67.08,15.62 R120.1 65.84,16.29 v2(65.78,16.23)
UNNAMED_10_ADMAX77675_I110_PVDD: length 16
  TOP w0.254: 68.24,15.22 65.97,15.22 65.56,15.63 U1.A2 ; C7.1 62.57,19.43 U1.D4
  BOTTOM w0.508: v1(61.72,20.57) 62.84,19.46 62.84,17.22 64.43,15.63 66.13,15.63 67.2,14.57 v1(67.73,14.57)
UNNAMED_10_ADMAX77675_I110_SBB0: length 2.1
  TOP w0.254: R139.1 65.06,13.84 U1.A3
UNNAMED_10_ADMAX77675_I110_SBB1: length 2.9
  TOP w0.254: R140.1 62.53,13.92 U1.A4
UNNAMED_10_ADMAX77675_I110_SBB2: length 2.2
  TOP w0.254: R141.1 62.59,16.45 U1.B4
UNNAMED_10_ADMAX77675_I110_SBB3: length 2.4
  TOP w0.254: R142.1 63.49,17.65 64.19,16.95 U1.C4
UNNAMED_10_ADMAX77675_I110_SCL: length 8.4
  TOP w0.203: U1.B1 69.11,16.45 v1(69.12,16.44)
  BOTTOM w0.203: R126.1 72.04,15.72 70.13,15.72 69.94,15.91 R125.1 v1(69.12,16.44) 68.96,16.29 R122.2
UNNAMED_10_ADMAX77675_I110_SDA: length 6.1
  TOP w0.203: U1.C1 68.55,16.95 v1(69.12,17.51)
  BOTTOM w0.203: R123.1 R124.1 v1(69.12,17.51) 68.91,17.72 R121.2
UNNAMED_10_DIOLED_I195_P: length 2.3
  TOP w0.508: DS3.A 75.83,50.81 v1(75.83,50.18)
  BOTTOM w0.508: R151.2 75.84,50.17 v1(75.83,50.18)
UNNAMED_10_DIOLED_I198_P: length 2.1
  TOP w0.508: DS4.A v1(79.88,50.16)
  BOTTOM w0.508: v1(79.88,50.16) 79.87,50.15 R152.2
UNNAMED_10_DIOLED_I201_P: length 2.1
  TOP w0.508: DS5.A v1(84.51,50.16)
  BOTTOM w0.508: v1(84.51,50.16) 84.46,50.12 R154.2
UNNAMED_10_RES_I124_N1: length 4.9
  BOTTOM w0.381: R149.2 R150.2 69.26,19.67 R121.1 68.37,19.32 68.15,19.1 R122.1
UNNAMED_10_RES_I143_N2: length 12.7
  TOP w0.203: v1(66.12,23.55) 66.11,23.55 R176.1 66.11,25.53 R137.2
  TOP w0.254: U1.C2 v2(65.78,17.17)
  BOTTOM w0.203: v2(65.78,17.17) 66.95,18.34 66.95,20.02 67.59,20.65 68.43,20.65 68.71,20.93 68.71,23.09 68.25,23.55 v1(66.12,23.55)
VOUT_3130: length 139.8
  TOP w0.279: 28.64,36.6 28.64,36.94 27.76,37.82 U2.14
  TOP w0.508: R144.2 52.44,33.35 v1(52.4,33.31) ; v1(32.82,20.18) v1(32.82,19.47) 32.82,18.78 v1(34.82,16.78) 35.13,16.47 v1(35.47,16.47) ; v1(81.78,38.72) 80.86,39.64 80.86,42.95 81.39,43.48 81.39,46.39 81.71,46.71 v1(82.23,46.71) ; R155.2 v1(25.4,35.88)
  TOP w0.762: v1(81.78,38.72) v1(81.78,38.01) 81.11,37.35 81.11,33.03 78.28,30.2 78.28,26.34 80.24,24.38 80.24,22.25 81.19,21.29 v1(82.53,21.29) v1(82.53,20.57)
  BOTTOM w0.508: v1(32.82,19.47) v1(32.82,20.18) 32.82,24.31 32.41,24.71 30.48,24.71 30.2,24.99 28.98,24.99 28.25,25.72 R145.1 27.39,25.68 26.26,25.68 26.11,25.53 24.51,25.53 23.99,26.05 R147.1 20.76,26.05 20.27,26.54 20.27,27.3 23.61,30.64 23.61,34.08 v1(25.4,35.88) ; v1(82.23,46.71) 82.23,47.7 R154.1 ; R164.2 R143.2 35.66,16.28 v1(35.47,16.47) 35.17,16.78 v1(34.82,16.78)
  BOTTOM w0.762: 82.21,38.09 82.54,38.09 84,36.63 84,33.38 83.54,32.92 74.27,32.92 73.58,32.23 66.8,32.23 64,35.04 64,36.82 62.32,38.49 59.5,38.49 57.35,36.35 57.35,35.23 56.26,34.14 55.14,34.14 54.32,33.31 v1(52.4,33.31) 46.57,33.31 44.27,35.61 40.87,35.61 39.55,34.29 37.39,34.29
  vias: v1(33.93,37.01) v1(33.93,36.25) v1(34.7,37.01) v1(34.7,36.25)
VS1: length 6
  TOP w0.203: U2.10 22.16,40.04 21.11,38.99 JP2.2
VS2: length 7.4
  TOP w0.203: JP3.2 21.08,42.67 21.23,42.52 21.23,40.87 21.56,40.54 U2.9
XTA_1261: length 8.8
  TOP w0.203: U4.3 25.48,17.59 v1(25.23,17.33) ; Y4.1 v1(24.63,11.24)
  L3_PWR w0.203: v1(25.23,17.33) 25.23,11.83 v1(24.63,11.24)
XTB_1261: length 5.9
  TOP w0.203: v1(26.37,14.16) 26.08,13.87 Y4.3 ; v1(26.37,17.33) 25.98,17.72 U4.4
  L3_PWR w0.203: v1(26.37,17.33) v1(26.37,14.16)

## Copper pours and planes (outline as drawn)
0V7_SSB2 on L3_PWR (solid shape): 62.51,16.08 62.51,14.58 61.8,13.87 61.01,13.87 60.88,14 60.88,15.88 61.39,16.38 62.2,16.38
0V7_SSB2 on TOP: 61.96,14.74 62.14,14.92 62.14,15.84 61.75,16.23 61.75,17.03 60.3,17.03 60.1,16.82 60.1,16.04 59.77,15.71 59.77,14.74
1V1_SSB1 on TOP: 61.75,13.49 61.75,14.28 60.1,14.28 60.1,13.5 59.77,13.17 59.77,12.2 59.82,12.15 63.39,12.15 63.67,12.43 63.67,12.89 63.23,13.32 61.91,13.32
1V8_SSB0 on TOP (solid shape): 83.97,22.45 83.97,21.41 83.36,21.41 81.94,22.83 81.94,22.96 83.46,22.96
1V8_SSB0 on L3_PWR (solid shape): 63.8,18.11 63.8,16.66 63.65,16.51 63.17,16.51 62.33,17.35 63.22,18.24 63.68,18.24
1V8_SSB0 on L3_PWR (solid shape): 51.16,11.76 51.16,11.58 51.1,11.53 49.23,11.53 49.12,11.63 49.12,11.84 49.89,12.6 50.32,12.6
1V8_SSB0 on L3_PWR (solid shape): 68.47,12.64 68.47,12.08 67.63,11.24 66.56,11.24 65.04,12.76 65.04,13.04 65.11,13.12 67.98,13.12
1V8_SSB0 on TOP: 81.39,41.87 81.39,41.14 83.1,39.43 83.71,39.43 83.86,39.59 83.86,40.86 83.48,41.24 82.38,41.24 81.67,41.95 81.47,41.95
1V8_SSB0 on TOP: 64.68,13.14 64.68,11.67 64.73,11.62 65.47,11.62 65.93,11.16 67.35,11.16 68.44,12.26 68.44,12.69 67.98,13.14
3V3_SSB3 on TOP (solid shape): 84.53,42.04 84.53,41.38 84.38,41.22 83.9,41.22 83.52,41.61 82.4,41.61 82.22,41.78 82.22,42.47 82.6,42.85 83.72,42.85
3V3_SSB3 on L3_PWR (solid shape): 83.5,25.34 83.5,23.48 83.32,23.3 82.44,23.3 82.23,23.51 82.23,25.57 82.44,25.77 83.07,25.77
3V3_SSB3 on L3_PWR (solid shape): 56.63,12.51 56.63,12.04 56.03,11.44 56.03,10.72 55.99,10.68 55.56,10.68 54.47,11.77 54.47,11.87 54.5,11.9 55.51,11.9 56.24,12.62 56.52,12.62
3V3_SSB3 on L3_PWR (solid shape): 66.03,30.82 66.03,30.34 64.58,28.89 63.49,28.89 63.35,29.03 63.35,29.84 62.41,30.78 62.41,30.99 62.5,31.08 65.77,31.08
3V3_SSB3 on L3_PWR (solid shape): outline of 108 points within 59.99,17.27 62.56,24.16
3V3_SSB3 on TOP: 61.75,17.28 61.75,17.98 62.08,18.31 62.08,19.3 61.93,19.46 60.2,19.46 60.1,19.35 60.1,18.58 59.77,18.25 59.77,17.28
3V3_SSB3 on TOP: 82.22,25.91 82.22,23.49 82.4,23.32 83.95,23.32 84.8,22.47 85.03,22.47 85.2,22.64 85.2,23.53 82.8,25.93 82.25,25.93
3V3_SSB3 on BOTTOM: 62.18,18.34 61.98,18.14 61.04,18.14 60.31,18.86 60.31,20.82 60.57,21.07 60.79,21.07 62.18,19.68
GND on TOP (solid shape): 30.26,19.52 30.26,19.01 30.2,18.96 29.24,18.96 28.5,19.69 28.5,19.8 29.98,19.8
GND on TOP (solid shape): 33.93,33.83 26.9,33.83 26.77,33.96 26.77,35.18 26.82,35.23 33.93,35.23
GND on TOP (solid shape): 25.22,41.68 25.86,41.68 25.98,41.55 26.49,41.55 26.49,40.92 21.67,40.92 21.54,41.05 21.54,42.06 21.67,42.19 24.71,42.19
GND on TOP (solid shape): 43.56,43.21 43.56,40.21 43.43,40.08 42.49,40.08 42.34,40.23 42.34,42.16 41.91,42.6 39.57,42.6 39.04,43.13 39.04,44.15 39.14,44.25 42.52,44.25
GND on TOP (solid shape): 34.42,46.66 34.42,43.87 34.44,43.84 34.44,43.48 34.19,43.23 31.75,43.23 31.5,43.48 31.5,43.99 31.75,44.25 31.75,46.66 32,46.91 34.16,46.91
GND on TOP (solid shape): 18.85,16.24 21.39,16.24 21.39,15.33 21.19,15.12 21.19,12.86 21.06,12.73 19.08,12.73 18.52,13.29 18.52,16.39 18.57,16.43 18.65,16.43
GND on TOP (solid shape): 47.28,44.95 48.15,44.95 48.7,44.4 48.95,44.4 49.05,44.3 49.05,43.99 47.89,42.84 47.89,42.63 47.75,42.49 47.24,42.99 47.24,44.95 47.26,44.97
GND on TOP (solid shape): 28.91,41.17 31.22,41.17 31.47,40.92 36.45,40.92 36.45,40.23 31.65,40.23 31.32,39.9 29.03,39.9 28.96,39.98 28.52,39.98 28.52,41.43 28.65,41.43
GND on TOP (solid shape): 21.19,12.68 21.49,12.38 22.31,12.38 22.31,11.77 20.68,11.77 20.68,10.63 31.29,10.63 31.29,11.77 29.07,11.77 29.06,11.79 29.06,12.83 29.07,12.84 32.8,12.84 33,12.63 33,9.28 18.9,9.28 18.9,13.32 21.19,13.32
GND on TOP (solid shape): 37.34,44.15 37.34,35.92 35.26,33.83 33.48,33.83 33.48,35.13 33.58,35.23 34.42,35.23 35.31,36.12 35.31,37.89 35.94,38.53 35.94,40.09 35.79,40.24 35.79,40.92 35.94,41.07 35.94,42.93 35.64,43.23 34.01,43.23 34.01,46.3 33.73,46.58 31.78,46.58 31.65,46.71 28.24,46.71 27.56,46.02 27.56,45.21 26.95,45.21 26.95,46.76 27.66,47.47 34.01,47.47
